* Synopsys Nettran: RHEL64 R-2020.09-SP3-3.6450417 2021/04/23
* Created:  12/15/2021   2:56
* Options: -cell ringpll -sp /nfs/sc/proj/ips/appg_SR_001/ /netlists/spice/ringpll.sp_ununiq -outName /nfs/sc/proj/ips/appg_SR_001/ /netlists/spice/ringpll.sp -outType spice -retainComments spice -sp-chopXPrefix

*.LENGTH_UNIT W WCON DX DY TERMLEN S
*.NON_UNIT MBOT TURNS MTOP TTYPE

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_outbuf_hn_clk
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_outbuf_hn_clk a o vccx vssx
* .PININFO a:I vccx:I vssx:I o:O
Mqna o n0 vssx vssx nlvt W=360n L=40n M=3
Mqn1 n0 a vssx vssx nlvt W=270n L=40n M=1
Mqp1 n0 a vccx vccx plvt W=270n L=40n M=1
Mqpa o n0 vccx vccx plvt W=315n L=40n M=4
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15ydp151an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ydp151an1n03x5 dpd1 vcc vssx m=1
* .PININFO dpd1:I vcc:B vssx:B
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_178
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_178 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=360n L=40n M=3
Mqpa o a vccxx vccxx plvt W=315n L=40n M=4
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no2_pcell_177
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no2_pcell_177 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlplvt W=90n L=40n M=1
Mqnb o b vssxx vssxx nlplvt W=90n L=40n M=1
Mqpb n1 b vccxx vccxx plplvt W=90n L=40n M=1
Mqpa o a n1 vccxx plplvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nor002ah1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002ah1n06x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plvt W=360n L=40n M=1
Mqp2 n1 b vcc vcc plvt W=360n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=270n L=40n M=1
Mqn2 o1 b vssx vssx nlvt W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15inv020ah1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv020ah1n05x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plvt W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=225n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv020an1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv020an1n05x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=180n L=40n M=1
Mqn1 o1 a vssx vssx n W=225n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no3_pcell_176
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no3_pcell_176 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqnc o c vssxx vssxx nlvt W=135n L=40n M=1
Mqnb o b vssxx vssxx nlvt W=135n L=40n M=1
Mqna o a vssxx vssxx nlvt W=135n L=40n M=1
Mqpc n1 c vccxx vccxx plvt W=180n L=40n M=1
Mqpb n2 b n1 vccxx plvt W=180n L=40n M=1
Mqpa o a n2 vccxx plvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15inv000ah1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000ah1n05x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plvt W=225n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=225n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15oai013ah1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai013ah1n02x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp2 o1 b n2 vcc plvt W=135n L=40n M=1
Mqp3 n2 c n3 vcc plvt W=135n L=40n M=1
Mqp4 n3 d vcc vcc plvt W=135n L=40n M=1
Mqp1 o1 a vcc vcc plvt W=90n L=40n M=1
Mqn2 n1 b vssx vssx nlvt W=90n L=40n M=1
Mqn3 n1 c vssx vssx nlvt W=90n L=40n M=1
Mqn4 n1 d vssx vssx nlvt W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15inv040ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv040ah1n03x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plvt W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15oai012ah1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai012ah1n02x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp3 n2 c vcc vcc plvt W=90n L=40n M=1
Mqp1 o1 a vcc vcc plvt W=90n L=40n M=1
Mqp2 o1 b n2 vcc plvt W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlvt W=90n L=40n M=1
Mqn2 n1 b vssx vssx nlvt W=90n L=40n M=1
Mqn3 n1 c vssx vssx nlvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oai013al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai013al1n02x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp2 o1 b n2 vcc plp W=135n L=40n M=1
Mqp3 n2 c n3 vcc plp W=135n L=40n M=1
Mqp4 n3 d vcc vcc plp W=135n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=90n L=40n M=1
Mqn3 n1 c vssx vssx nlp W=90n L=40n M=1
Mqn4 n1 d vssx vssx nlp W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no3_pcell_175
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no3_pcell_175 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqnc o c vssxx vssxx nlp W=90n L=40n M=1
Mqnb o b vssxx vssxx nlp W=90n L=40n M=1
Mqna o a vssxx vssxx nlp W=90n L=40n M=1
Mqpc n1 c vccxx vccxx plp W=135n L=40n M=1
Mqpb n2 b n1 vccxx plp W=135n L=40n M=1
Mqpa o a n2 vccxx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor004al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor004al1n02x3 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=90n L=40n M=1
Mqp2 n1 b n2 vcc plp W=90n L=40n M=1
Mqp3 n2 c n3 vcc plp W=90n L=40n M=1
Mqp4 n3 d vcc vcc plp W=90n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
Mqn3 o1 c vssx vssx nlp W=90n L=40n M=1
Mqn4 o1 d vssx vssx nlp W=90n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor003al1n02x7
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor003al1n02x7 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 n1 b n2 vcc plp W=180n L=40n M=1
Mqp3 n2 c vcc vcc plp W=180n L=40n M=1
Mqp1 o1 a n1 vcc plp W=180n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=90n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
Mqn3 o1 c vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nano22al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nano22al1n03x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Mqn3 n0 b vssx vssx nlp W=135n L=40n M=1
Mqn0 n1 a n0 vssx nlp W=135n L=40n M=1
Mqn1 out0 n1 vssx vssx nlp W=135n L=40n M=1
Mqn2 out0 c vssx vssx nlp W=135n L=40n M=1
Mqp3 n1 a vcc vcc plp W=90n L=40n M=1
Mqp0 n1 b vcc vcc plp W=90n L=40n M=1
Mqp1 out0 n1 n2 vcc plp W=180n L=40n M=1
Mqp2 n2 c vcc vcc plp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv020al1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv020al1n05x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=225n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nor002an1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002an1n06x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc p W=360n L=40n M=1
Mqp2 n1 b vcc vcc p W=360n L=40n M=1
Mqn1 o1 a vssx vssx n W=270n L=40n M=1
Mqn2 o1 b vssx vssx n W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nandp2al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nandp2al1n04x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=180n L=40n M=1
Mqp1 o1 a vcc vcc plp W=180n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=180n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15aoi022an1n04x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi022an1n04x3 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqn4 n3 d vssx vssx n W=180n L=40n M=1
Mqn2 n2 b vssx vssx n W=180n L=40n M=1
Mqn1 o1 a n2 vssx n W=180n L=40n M=1
Mqn3 o1 c n3 vssx n W=180n L=40n M=1
Mqp1 o1 a n1 vcc p W=90n L=40n M=1
Mqp3 n1 c vcc vcc p W=90n L=40n M=1
Mqp4 n1 d vcc vcc p W=90n L=40n M=1
Mqp2 o1 b n1 vcc p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15aoi122al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi122al1n04x5 a b c d e o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I e:I o1:O vcc:B vssx:B
Mqp4 n2 b n1 vcc plp W=360n L=40n M=1
Mqp3 n2 c n1 vcc plp W=360n L=40n M=1
Mqp2 n1 d vcc vcc plp W=360n L=40n M=1
Mqp1 n1 e vcc vcc plp W=360n L=40n M=1
Mqp5 o1 a n2 vcc plp W=360n L=40n M=1
Mqn2 n3 d vssx vssx nlp W=270n L=40n M=1
Mqn1 o1 e n3 vssx nlp W=270n L=40n M=1
Mqn5 o1 a vssx vssx nlp W=180n L=40n M=1
Mqn4 n4 b vssx vssx nlp W=270n L=40n M=1
Mqn3 o1 c n4 vssx nlp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_174
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_174 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx n W=225n L=40n M=1
Mqnb n1 b vssxx vssxx n W=225n L=40n M=1
Mqpb o b vccxx vccxx p W=180n L=40n M=1
Mqpa o a vccxx vccxx p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_173
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_173 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlvt W=180n L=40n M=1
Mqnb n1 b vssxx vssxx nlvt W=180n L=40n M=1
Mqpb o b vccxx vccxx plvt W=135n L=40n M=1
Mqpa o a vccxx vccxx plvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oai013al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai013al1n02x3 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp2 o1 b n2 vcc plp W=90n L=40n M=1
Mqp3 n2 c n3 vcc plp W=90n L=40n M=1
Mqp4 n3 d vcc vcc plp W=90n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=90n L=40n M=1
Mqn3 n1 c vssx vssx nlp W=90n L=40n M=1
Mqn4 n1 d vssx vssx nlp W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_172
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_172 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=360n L=40n M=6
Mqpa o a vccxx vccxx plvt W=180n L=40n M=13
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nona23ah1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nona23ah1n16x5 a b c d out0 vcc vssx m=1
* .PININFO a:I b:I c:I d:I out0:O vcc:B vssx:B
Mqn4 n4 a vssx vssx nlvt W=270n L=40n M=1
Mqn0 n4 b vssx vssx nlvt W=270n L=40n M=1
Mqn1 out0 n4 n1 vssx nlvt W=720n L=40n M=1
Mqn2 n1 c n2 vssx nlvt W=720n L=40n M=1
Mqn3 n2 d vssx vssx nlvt W=720n L=40n M=1
Mqp4 n4 a n3 vcc plvt W=360n L=40n M=1
Mqp0 n3 b vcc vcc plvt W=360n L=40n M=1
Mqp2 out0 c vcc vcc plvt W=540n L=40n M=1
Mqp3 out0 d vcc vcc plvt W=540n L=40n M=1
Mqp1 out0 n4 vcc vcc plvt W=540n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nor004an1n02x7
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor004an1n02x7 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqn1 o1 a vssx vssx n W=90n L=40n M=1
Mqn3 o1 c vssx vssx n W=90n L=40n M=1
Mqn4 o1 d vssx vssx n W=90n L=40n M=1
Mqn2 o1 b vssx vssx n W=90n L=40n M=1
Mqp1 o1 a n1 vcc p W=180n L=40n M=1
Mqp2 n1 b n2 vcc p W=180n L=40n M=1
Mqp3 n2 c n3 vcc p W=180n L=40n M=1
Mqp4 n3 d vcc vcc p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_171
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_171 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx n W=360n L=40n M=3
Mqnb n1 b vssxx vssxx n W=360n L=40n M=3
Mqpb o b vccxx vccxx p W=360n L=40n M=2
Mqpa o a vccxx vccxx p W=360n L=40n M=2
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_170
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_170 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx n W=270n L=40n M=2
Mqnb n1 b vssxx vssxx n W=270n L=40n M=2
Mqpb o b vccxx vccxx p W=360n L=40n M=1
Mqpa o a vccxx vccxx p W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_169
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_169 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=90n L=40n M=1
Mqpa o a vccxx vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15aoi012an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi012an1n02x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp3 n1 c vcc vcc p W=135n L=40n M=1
Mqp2 n1 b vcc vcc p W=135n L=40n M=1
Mqp1 o1 a n1 vcc p W=135n L=40n M=1
Mqn3 n2 c vssx vssx n W=135n L=40n M=1
Mqn2 o1 b n2 vssx n W=135n L=40n M=1
Mqn1 o1 a vssx vssx n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15norp02al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15norp02al1n02x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=90n L=40n M=1
Mqp2 n1 b vcc vcc plp W=90n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nandp2an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nandp2an1n04x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc p W=180n L=40n M=1
Mqp1 o1 a vcc vcc p W=180n L=40n M=1
Mqn2 n1 b vssx vssx n W=180n L=40n M=1
Mqn1 o1 a n1 vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15oai012an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai012an1n03x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp3 n2 c vcc vcc p W=135n L=40n M=1
Mqp1 o1 a vcc vcc p W=90n L=40n M=1
Mqp2 o1 b n2 vcc p W=135n L=40n M=1
Mqn1 o1 a n1 vssx n W=135n L=40n M=1
Mqn2 n1 b vssx vssx n W=135n L=40n M=1
Mqn3 n1 c vssx vssx n W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15inv020ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv020ah1n03x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plvt W=90n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15norp02ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15norp02ah1n03x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plvt W=135n L=40n M=1
Mqp2 n1 b vcc vcc plvt W=135n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=135n L=40n M=1
Mqn2 o1 b vssx vssx nlvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_168
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_168 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx n W=180n L=40n M=1
Mqnb n1 b vssxx vssxx n W=180n L=40n M=1
Mqpb o b vccxx vccxx p W=135n L=40n M=1
Mqpa o a vccxx vccxx p W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no2_pcell_167
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no2_pcell_167 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=90n L=40n M=1
Mqnb o b vssxx vssxx nlvt W=90n L=40n M=1
Mqpb n1 b vccxx vccxx plvt W=90n L=40n M=1
Mqpa o a n1 vccxx plvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no2_pcell_166
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no2_pcell_166 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=90n L=40n M=1
Mqnb o b vssxx vssxx nlvt W=90n L=40n M=1
Mqpb n1 b vccxx vccxx plvt W=135n L=40n M=1
Mqpa o a n1 vccxx plvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oai122al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai122al1n02x5 a b c d e o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I e:I o1:O vcc:B vssx:B
Mqp3 n3 c vcc vcc plp W=90n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqp5 n4 e vcc vcc plp W=90n L=40n M=1
Mqp4 o1 d n4 vcc plp W=90n L=40n M=1
Mqp2 o1 b n3 vcc plp W=90n L=40n M=1
Mqn5 n2 e vssx vssx nlp W=90n L=40n M=1
Mqn2 n1 b n2 vssx nlp W=90n L=40n M=1
Mqn4 n2 d vssx vssx nlp W=90n L=40n M=1
Mqn3 n1 c n2 vssx nlp W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15aoi012an1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi012an1n02x3 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp3 n1 c vcc vcc p W=90n L=40n M=1
Mqp2 n1 b vcc vcc p W=90n L=40n M=1
Mqp1 o1 a n1 vcc p W=90n L=40n M=1
Mqn3 n2 c vssx vssx n W=90n L=40n M=1
Mqn2 o1 b n2 vssx n W=90n L=40n M=1
Mqn1 o1 a vssx vssx n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no3_pcell_165
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no3_pcell_165 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqnc o c vssxx vssxx n W=135n L=40n M=1
Mqnb o b vssxx vssxx n W=135n L=40n M=1
Mqna o a vssxx vssxx n W=135n L=40n M=1
Mqpc n1 c vccxx vccxx p W=180n L=40n M=1
Mqpb n2 b n1 vccxx p W=180n L=40n M=1
Mqpa o a n2 vccxx p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no3_pcell_164
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no3_pcell_164 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqnc o c vssxx vssxx nlvt W=90n L=40n M=1
Mqnb o b vssxx vssxx nlvt W=90n L=40n M=1
Mqna o a vssxx vssxx nlvt W=90n L=40n M=1
Mqpc n1 c vccxx vccxx plvt W=135n L=40n M=1
Mqpb n2 b n1 vccxx plvt W=135n L=40n M=1
Mqpa o a n2 vccxx plvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_163
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_163 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlvt W=360n L=40n M=2
Mqnb n1 b vssxx vssxx nlvt W=360n L=40n M=2
Mqpb o b vccxx vccxx plvt W=270n L=40n M=2
Mqpa o a vccxx vccxx plvt W=270n L=40n M=2
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15aoi122an1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi122an1n02x3 a b c d e o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I e:I o1:O vcc:B vssx:B
Mqn2 n3 d vssx vssx n W=90n L=40n M=1
Mqn1 o1 e n3 vssx n W=90n L=40n M=1
Mqn5 o1 a vssx vssx n W=90n L=40n M=1
Mqn4 n4 b vssx vssx n W=90n L=40n M=1
Mqn3 o1 c n4 vssx n W=90n L=40n M=1
Mqp4 n2 b n1 vcc p W=90n L=40n M=1
Mqp3 n2 c n1 vcc p W=90n L=40n M=1
Mqp2 n1 d vcc vcc p W=90n L=40n M=1
Mqp1 n1 e vcc vcc p W=90n L=40n M=1
Mqp5 o1 a n2 vcc p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    td_pcell_162
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__td_pcell_162 ck ckb d o vccxx vssxx
* .PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqnck o ck n2 vssxx n W=135n L=40n M=1
Mqnd n2 d vssxx vssxx n W=135n L=40n M=1
Mqpckb o ckb n1 vccxx p W=135n L=40n M=1
Mqpd n1 d vccxx vccxx p W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_161
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_161 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx n W=135n L=40n M=1
Mqpsb o sb i vccxx p W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_160
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_160 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx n W=180n L=40n M=1
Mqpsb o sb i vccxx p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_159
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_159 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=270n L=40n M=1
Mqpa o a vccxx vccxx p W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_158
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_158 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=360n L=40n M=1
Mqpa o a vccxx vccxx p W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15norp02an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15norp02an1n04x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc p W=180n L=40n M=1
Mqp2 n1 b vcc vcc p W=180n L=40n M=1
Mqn1 o1 a vssx vssx n W=180n L=40n M=1
Mqn2 o1 b vssx vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15norp02an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15norp02an1n03x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc p W=135n L=40n M=1
Mqp2 n1 b vcc vcc p W=135n L=40n M=1
Mqn1 o1 a vssx vssx n W=135n L=40n M=1
Mqn2 o1 b vssx vssx n W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15norp02ah1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15norp02ah1n08x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plvt W=360n L=40n M=1
Mqp2 n1 b vcc vcc plvt W=360n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=360n L=40n M=1
Mqn2 o1 b vssx vssx nlvt W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nand04al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand04al1n02x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=90n L=40n M=1
Mqp3 o1 c vcc vcc plp W=90n L=40n M=1
Mqp4 o1 d vcc vcc plp W=90n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=90n L=40n M=1
Mqn2 n1 b n2 vssx nlp W=90n L=40n M=1
Mqn3 n2 c n3 vssx nlp W=90n L=40n M=1
Mqn4 n3 d vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15aoi122al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi122al1n02x3 a b c d e o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I e:I o1:O vcc:B vssx:B
Mqp4 n2 b n1 vcc plp W=90n L=40n M=1
Mqp3 n2 c n1 vcc plp W=90n L=40n M=1
Mqp2 n1 d vcc vcc plp W=90n L=40n M=1
Mqp1 n1 e vcc vcc plp W=90n L=40n M=1
Mqp5 o1 a n2 vcc plp W=90n L=40n M=1
Mqn2 n3 d vssx vssx nlp W=90n L=40n M=1
Mqn1 o1 e n3 vssx nlp W=90n L=40n M=1
Mqn5 o1 a vssx vssx nlp W=90n L=40n M=1
Mqn4 n4 b vssx vssx nlp W=90n L=40n M=1
Mqn3 o1 c n4 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15rm6013en1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15rm6013en1n04x5 a b c carryb vcc vssx m=1
* .PININFO a:I b:I c:I carryb:O vcc:B vssx:B
Mqp31 carryb b n3 vcc p W=180n L=40n M=1
Mqp30 n3 a vcc vcc p W=180n L=40n M=1
Mqp10 n0 b vcc vcc p W=180n L=40n M=1
Mqp11 carryb c n0 vcc p W=180n L=40n M=1
Mqp20 n0 a vcc vcc p W=180n L=40n M=1
Mqn31 carryb b n4 vssx n W=180n L=40n M=1
Mqn30 n4 a vssx vssx n W=180n L=40n M=1
Mqn20 n2 a vssx vssx n W=180n L=40n M=1
Mqn10 n2 b vssx vssx n W=180n L=40n M=1
Mqn11 carryb c n2 vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15rm6013el1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15rm6013el1n02x5 a b c carryb vcc vssx m=1
* .PININFO a:I b:I c:I carryb:O vcc:B vssx:B
Mqp31 carryb b n3 vcc plp W=90n L=40n M=1
Mqp30 n3 a vcc vcc plp W=90n L=40n M=1
Mqp10 n0 b vcc vcc plp W=90n L=40n M=1
Mqp11 carryb c n0 vcc plp W=90n L=40n M=1
Mqp20 n0 a vcc vcc plp W=90n L=40n M=1
Mqn31 carryb b n4 vssx nlp W=90n L=40n M=1
Mqn30 n4 a vssx vssx nlp W=90n L=40n M=1
Mqn20 n2 a vssx vssx nlp W=90n L=40n M=1
Mqn10 n2 b vssx vssx nlp W=90n L=40n M=1
Mqn11 carryb c n2 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15aoi022an1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi022an1n02x3 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqn4 n3 d vssx vssx n W=90n L=40n M=1
Mqn2 n2 b vssx vssx n W=90n L=40n M=1
Mqn1 o1 a n2 vssx n W=90n L=40n M=1
Mqn3 o1 c n3 vssx n W=90n L=40n M=1
Mqp1 o1 a n1 vcc p W=90n L=40n M=1
Mqp3 n1 c vcc vcc p W=90n L=40n M=1
Mqp4 n1 d vcc vcc p W=90n L=40n M=1
Mqp2 o1 b n1 vcc p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_157
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_157 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=360n L=40n M=8
Mqpa o a vccxx vccxx plvt W=180n L=40n M=17
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oaoi13al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oaoi13al1n03x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp2 n2 c n1 vcc plp W=270n L=40n M=1
Mqp3 n2 b vcc vcc plp W=135n L=40n M=1
Mqp4 o1 a n2 vcc plp W=135n L=40n M=1
Mqp1 n1 d vcc vcc plp W=270n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=135n L=40n M=1
Mqn3 n3 d vssx vssx nlp W=135n L=40n M=1
Mqn4 n3 c vssx vssx nlp W=135n L=40n M=1
Mqn2 o1 b n3 vssx nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_156
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_156 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlvt W=135n L=40n M=1
Mqnb n1 b vssxx vssxx nlvt W=135n L=40n M=1
Mqpb o b vccxx vccxx plvt W=90n L=40n M=1
Mqpa o a vccxx vccxx plvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15aoi112al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi112al1n02x3 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp1 n2 d vcc vcc plp W=90n L=40n M=1
Mqp2 n2 c vcc vcc plp W=90n L=40n M=1
Mqp3 n3 b n2 vcc plp W=90n L=40n M=1
Mqp4 o1 a n3 vcc plp W=90n L=40n M=1
Mqn3 o1 b vssx vssx nlp W=90n L=40n M=1
Mqn2 o1 c n0 vssx nlp W=90n L=40n M=1
Mqn1 n0 d vssx vssx nlp W=90n L=40n M=1
Mqn4 o1 a vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no3_pcell_155
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no3_pcell_155 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqnc o c vssxx vssxx n W=90n L=40n M=1
Mqnb o b vssxx vssxx n W=90n L=40n M=1
Mqna o a vssxx vssxx n W=90n L=40n M=1
Mqpc n1 c vccxx vccxx p W=135n L=40n M=1
Mqpb n2 b n1 vccxx p W=135n L=40n M=1
Mqpa o a n2 vccxx p W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_154
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_154 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=360n L=40n M=2
Mqpa o a vccxx vccxx plvt W=360n L=40n M=2
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_153
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_153 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=360n L=40n M=4
Mqpa o a vccxx vccxx plvt W=270n L=40n M=6
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_152
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_152 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlvt W=360n L=40n M=2
Mqpsb o sb i vccxx plvt W=360n L=40n M=2
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oai112al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai112al1n02x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp3 o1 c n3 vcc plp W=90n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqp2 o1 b vcc vcc plp W=90n L=40n M=1
Mqp4 n3 d vcc vcc plp W=90n L=40n M=1
Mqn4 n2 d vssx vssx nlp W=90n L=40n M=1
Mqn3 n2 c vssx vssx nlp W=90n L=40n M=1
Mqn2 n1 b n2 vssx nlp W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    bo2na2_pcell_151
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__bo2na2_pcell_151 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqna o a n0 vssxx nlp W=180n L=40n M=1
Mqnb n0 b vssxx vssxx nlp W=180n L=40n M=1
Mqnc n0 c vssxx vssxx nlp W=180n L=40n M=1
Mqpb o b n1 vccxx plp W=180n L=40n M=1
Mqpc n1 c vccxx vccxx plp W=180n L=40n M=1
Mqpa o a vccxx vccxx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15aoi022al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi022al1n02x3 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=90n L=40n M=1
Mqp3 n1 c vcc vcc plp W=90n L=40n M=1
Mqp4 n1 d vcc vcc plp W=90n L=40n M=1
Mqp2 o1 b n1 vcc plp W=90n L=40n M=1
Mqn4 n3 d vssx vssx nlp W=90n L=40n M=1
Mqn2 n2 b vssx vssx nlp W=90n L=40n M=1
Mqn1 o1 a n2 vssx nlp W=90n L=40n M=1
Mqn3 o1 c n3 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15oai012an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai012an1n02x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp3 n2 c vcc vcc p W=90n L=40n M=1
Mqp1 o1 a vcc vcc p W=90n L=40n M=1
Mqp2 o1 b n2 vcc p W=90n L=40n M=1
Mqn1 o1 a n1 vssx n W=90n L=40n M=1
Mqn2 n1 b vssx vssx n W=90n L=40n M=1
Mqn3 n1 c vssx vssx n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nandp3an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nandp3an1n03x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc p W=135n L=40n M=1
Mqp3 o1 c vcc vcc p W=135n L=40n M=1
Mqp1 o1 a vcc vcc p W=135n L=40n M=1
Mqn1 o1 a n1 vssx n W=135n L=40n M=1
Mqn2 n1 b n2 vssx n W=135n L=40n M=1
Mqn3 n2 c vssx vssx n W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor003al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor003al1n02x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 n1 b n2 vcc plp W=135n L=40n M=1
Mqp3 n2 c vcc vcc plp W=135n L=40n M=1
Mqp1 o1 a n1 vcc plp W=135n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=90n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
Mqn3 o1 c vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nand02ah1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02ah1n06x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plvt W=180n L=40n M=1
Mqp1 o1 a vcc vcc plvt W=180n L=40n M=1
Mqn2 n1 b vssx vssx nlvt W=270n L=40n M=1
Mqn1 o1 a n1 vssx nlvt W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv040an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv040an1n03x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=180n L=40n M=1
Mqn1 o1 a vssx vssx n W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15revid0an1nm1x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15revid0an1nm1x5 o vcc vssx m=1
* .PININFO o:O vcc:B vssx:B
Rg1 o vssx rm1fm2 W=0.068u L=0.046u M=1
Mqn1 n1 vssx vssx vssx n W=90n L=40n M=1
Mqp1 n1 vssx vcc vcc p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv040an1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv040an1n06x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=360n L=40n M=1
Mqn1 o1 a vssx vssx n W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_150
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_150 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlplvt W=180n L=40n M=1
Mqnb n1 b vssxx vssxx nlplvt W=180n L=40n M=1
Mqpb o b vccxx vccxx plplvt W=90n L=40n M=1
Mqpa o a vccxx vccxx plplvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oaoi13al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oaoi13al1n02x3 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp2 n2 c n1 vcc plp W=90n L=40n M=1
Mqp3 n2 b vcc vcc plp W=90n L=40n M=1
Mqp4 o1 a n2 vcc plp W=90n L=40n M=1
Mqp1 n1 d vcc vcc plp W=90n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
Mqn3 n3 d vssx vssx nlp W=90n L=40n M=1
Mqn4 n3 c vssx vssx nlp W=90n L=40n M=1
Mqn2 o1 b n3 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15aoi012ah1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi012ah1n02x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp3 n1 c vcc vcc plvt W=135n L=40n M=1
Mqp2 n1 b vcc vcc plvt W=135n L=40n M=1
Mqp1 o1 a n1 vcc plvt W=135n L=40n M=1
Mqn3 n2 c vssx vssx nlvt W=135n L=40n M=1
Mqn2 o1 b n2 vssx nlvt W=135n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv040al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv040al1n03x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oai012al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai012al1n02x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp3 n2 c vcc vcc plp W=90n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqp2 o1 b n2 vcc plp W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=90n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=90n L=40n M=1
Mqn3 n1 c vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_149
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_149 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx n W=90n L=40n M=1
Mqnb n1 b vssxx vssxx n W=90n L=40n M=1
Mqpb o b vccxx vccxx p W=90n L=40n M=1
Mqpa o a vccxx vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oai022al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai022al1n02x3 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp3 o1 c n3 vcc plp W=90n L=40n M=1
Mqp1 o1 a n2 vcc plp W=90n L=40n M=1
Mqp2 n2 b vcc vcc plp W=90n L=40n M=1
Mqp4 n3 d vcc vcc plp W=90n L=40n M=1
Mqn2 o1 b n1 vssx nlp W=90n L=40n M=1
Mqn4 n1 d vssx vssx nlp W=90n L=40n M=1
Mqn3 n1 c vssx vssx nlp W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    bo2na2_pcell_148
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__bo2na2_pcell_148 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqna o a n0 vssxx nlp W=135n L=40n M=1
Mqnb n0 b vssxx vssxx nlp W=135n L=40n M=1
Mqnc n0 c vssxx vssxx nlp W=135n L=40n M=1
Mqpb o b n1 vccxx plp W=135n L=40n M=1
Mqpc n1 c vccxx vccxx plp W=135n L=40n M=1
Mqpa o a vccxx vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no2_pcell_147
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no2_pcell_147 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=90n L=40n M=1
Mqnb o b vssxx vssxx n W=90n L=40n M=1
Mqpb n1 b vccxx vccxx p W=90n L=40n M=1
Mqpa o a n1 vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15aoai13al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoai13al1n02x3 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp1 n1 c vcc vcc plp W=90n L=40n M=1
Mqp3 o1 b n1 vcc plp W=90n L=40n M=1
Mqp2 n1 d vcc vcc plp W=90n L=40n M=1
Mqp4 o1 a vcc vcc plp W=90n L=40n M=1
Mqn4 n3 d vssx vssx nlp W=90n L=40n M=1
Mqn2 n2 b vssx vssx nlp W=90n L=40n M=1
Mqn1 o1 a n2 vssx nlp W=90n L=40n M=1
Mqn3 n2 c n3 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nand03al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand03al1n03x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=90n L=40n M=1
Mqp3 o1 c vcc vcc plp W=90n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=135n L=40n M=1
Mqn2 n1 b n2 vssx nlp W=135n L=40n M=1
Mqn3 n2 c vssx vssx nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    td_pcell_146
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__td_pcell_146 ck ckb d o vccxx vssxx
* .PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqnck o ck n2 vssxx nlp W=45n L=40n M=1
Mqnd n2 d vssxx vssxx nlp W=45n L=40n M=1
Mqpckb o ckb n1 vccxx plp W=45n L=40n M=1
Mqpd n1 d vccxx vccxx plp W=45n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_145
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_145 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlplvt W=90n L=40n M=1
Mqpa o a vccxx vccxx plplvt W=45n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_144
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_144 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlplvt W=45n L=40n M=1
Mqpa o a vccxx vccxx plplvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_143
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_143 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=45n L=40n M=1
Mqpa o a vccxx vccxx plp W=45n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_142
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_142 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlp W=45n L=40n M=1
Mqpsb o sb i vccxx plp W=45n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15aoi012al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi012al1n02x3 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp3 n1 c vcc vcc plp W=90n L=40n M=1
Mqp2 n1 b vcc vcc plp W=90n L=40n M=1
Mqp1 o1 a n1 vcc plp W=90n L=40n M=1
Mqn3 n2 c vssx vssx nlp W=90n L=40n M=1
Mqn2 o1 b n2 vssx nlp W=90n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15norp02al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15norp02al1n03x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=135n L=40n M=1
Mqp2 n1 b vcc vcc plp W=135n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=135n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv040al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv040al1n02x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=135n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_141
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_141 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlvt W=90n L=40n M=1
Mqnb n1 b vssxx vssxx nlvt W=90n L=40n M=1
Mqpb o b vccxx vccxx plvt W=90n L=40n M=1
Mqpa o a vccxx vccxx plvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nand02al1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02al1n16x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=540n L=40n M=1
Mqp1 o1 a vcc vcc plp W=540n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=720n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=720n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cinv00ah1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cinv00ah1n06x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 clkout clk vcc vcc plvt W=270n L=40n M=1
Mqn1 clkout clk vssx vssx nlvt W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_140
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_140 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlp W=360n L=40n M=2
Mqnb n1 b vssxx vssxx nlp W=360n L=40n M=2
Mqpb o b vccxx vccxx plp W=270n L=40n M=2
Mqpa o a vccxx vccxx plp W=270n L=40n M=2
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nand04al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand04al1n04x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=135n L=40n M=1
Mqp3 o1 c vcc vcc plp W=135n L=40n M=1
Mqp4 o1 d vcc vcc plp W=135n L=40n M=1
Mqp1 o1 a vcc vcc plp W=135n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=180n L=40n M=1
Mqn2 n1 b n2 vssx nlp W=180n L=40n M=1
Mqn3 n2 c n3 vssx nlp W=180n L=40n M=1
Mqn4 n3 d vssx vssx nlp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor004al1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor004al1n06x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=360n L=40n M=1
Mqp2 n1 b n2 vcc plp W=360n L=40n M=1
Mqp3 n2 c n3 vcc plp W=360n L=40n M=1
Mqp4 n3 d vcc vcc plp W=360n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=270n L=40n M=1
Mqn3 o1 c vssx vssx nlp W=270n L=40n M=1
Mqn4 o1 d vssx vssx nlp W=270n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nor002an1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002an1n12x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc p W=720n L=40n M=1
Mqp2 n1 b vcc vcc p W=720n L=40n M=1
Mqn1 o1 a vssx vssx n W=540n L=40n M=1
Mqn2 o1 b vssx vssx n W=540n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_132
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_132 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=135n L=40n M=1
Mqpa o a vccxx vccxx p W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor002al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002al1n02x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=135n L=40n M=1
Mqp2 n1 b vcc vcc plp W=135n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n05x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=225n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=225n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_131
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_131 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlp W=180n L=40n M=1
Mqpsb o sb i vccxx plp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_130
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_130 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx n W=90n L=40n M=1
Mqnb n1 b vssxx vssxx n W=90n L=40n M=1
Mqpb o b vccxx vccxx p W=90n L=40n M=1
Mqpa o a vccxx vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_ljpll_2nal74stack
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_ljpll_2nal74stack b d g s
* .PININFO g:I b:B d:B s:B
Mmn0 sd01 g s b nal74 W=360n L=74n M=1
Mmn1 d g sd01 b nal74 W=360n L=74n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nand02an1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02an1n08x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc p W=270n L=40n M=1
Mqp1 o1 a vcc vcc p W=270n L=40n M=1
Mqn2 n1 b vssx vssx n W=360n L=40n M=1
Mqn1 o1 a n1 vssx n W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_ljpll_2pal74stack
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_ljpll_2pal74stack b d g s
* .PININFO g:I b:B d:B s:B
Mmp0 d g sd01 b pal74 W=270n L=74n M=1
Mmp1 sd01 g s b pal74 W=270n L=74n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n32x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n32x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=1.44u L=40n M=1
Mqn1 o1 a vssx vssx nlp W=1.44u L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv000an1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000an1n08x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=360n L=40n M=1
Mqn1 o1 a vssx vssx n W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n48x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n48x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=2.16u L=40n M=1
Mqn1 o1 a vssx vssx nlp W=2.16u L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n12x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=540n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=540n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nand02an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02an1n02x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc p W=90n L=40n M=1
Mqp1 o1 a vcc vcc p W=90n L=40n M=1
Mqn2 n1 b vssx vssx n W=90n L=40n M=1
Mqn1 o1 a n1 vssx n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_ljpll_2nal74stack_qslice
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_ljpll_2nal74stack_qslice b d g s
* .PININFO g:I b:B d:B s:B
Mmn1 sd01_a g s b nal74 W=180n L=74n M=1
Mmn2 sd01 g s b nal74 W=180n L=74n M=1
Mmn0 d g sd01_a b nal74 W=180n L=74n M=1
Mmn3 d g sd01 b nal74 W=180n L=74n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nand02an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02an1n04x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc p W=135n L=40n M=1
Mqp1 o1 a vcc vcc p W=135n L=40n M=1
Mqn2 n1 b vssx vssx n W=180n L=40n M=1
Mqn1 o1 a n1 vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_ljpll_2pal74stack_qslice
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_ljpll_2pal74stack_qslice b d g s
* .PININFO g:I b:B d:B s:B
Mmp3 d g sd01_a b pal74 W=135n L=74n M=1
Mmp0 d g sd01 b pal74 W=135n L=74n M=1
Mmp1 sd01 g s b pal74 W=135n L=74n M=1
Mmp2 sd01_a g s b pal74 W=135n L=74n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vcorostage
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vcorostage ro cb[2] cb[1] cb[0] ri vccvco vssx
* .PININFO cb[2]:I cb[1]:I cb[0]:I ri:I vccvco:I vssx:I ro:O
Mmp0 ro ri vccvco vccvco p W=180n L=40n M=8
Mmn0 ro ri vssx vssx n W=180n L=40n M=8
Mmn4 sw2 cb[2] ro vssx nlvt W=180n L=40n M=4
Mmn3 sw1 cb[1] ro vssx nlvt W=180n L=40n M=2
Mmn2 sw0 cb[0] ro vssx nlvt W=180n L=40n M=2
Mmp2 vccvco sw0 vccvco vccvco plvt W=360n L=40n M=4
Mmp4 vccvco sw2 vccvco vccvco plvt W=360n L=40n M=16
Mmp3 vccvco sw1 vccvco vccvco plvt W=360n L=40n M=8
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor003al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor003al1n03x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 n1 b n2 vcc plp W=180n L=40n M=1
Mqp3 n2 c vcc vcc plp W=180n L=40n M=1
Mqp1 o1 a n1 vcc plp W=180n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=135n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=135n L=40n M=1
Mqn3 o1 c vssx vssx nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    plp_s_pcell_124
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__plp_s_pcell_124 d g s b
* .PININFO b:B d:B g:B s:B
Mi16 inet15 g s b plp W=90n L=40n M=1
Mi15 inet14 g inet15 b plp W=90n L=40n M=1
Mi14 inet13 g inet14 b plp W=90n L=40n M=1
Mi13 inet12 g inet13 b plp W=90n L=40n M=1
Mi12 inet11 g inet12 b plp W=90n L=40n M=1
Mi11 inet10 g inet11 b plp W=90n L=40n M=1
Mi10 inet9 g inet10 b plp W=90n L=40n M=1
Mi9 inet8 g inet9 b plp W=90n L=40n M=1
Mi8 inet7 g inet8 b plp W=90n L=40n M=1
Mi7 inet6 g inet7 b plp W=90n L=40n M=1
Mi6 inet5 g inet6 b plp W=90n L=40n M=1
Mi5 inet4 g inet5 b plp W=90n L=40n M=1
Mi4 inet3 g inet4 b plp W=90n L=40n M=1
Mi3 inet2 g inet3 b plp W=90n L=40n M=1
Mi2 inet1 g inet2 b plp W=90n L=40n M=1
Mi1 d g inet1 b plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    nlvt_s_pcell_123
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__nlvt_s_pcell_123 d g s b
* .PININFO b:B d:B g:B s:B
Mi1 d g inet1 b nlvt W=135n L=40n M=1
Mi2 inet1 g s b nlvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    plvt_s_pcell_122
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__plvt_s_pcell_122 d g s b
* .PININFO b:B d:B g:B s:B
Mi2 inet1 g s b plvt W=135n L=40n M=1
Mi1 d g inet1 b plvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    p_s_pcell_119
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__p_s_pcell_119 d g s b
* .PININFO b:B d:B g:B s:B
Mi6 inet5 g s b p W=180n L=40n M=1
Mi5 inet4 g inet5 b p W=180n L=40n M=1
Mi4 inet3 g inet4 b p W=180n L=40n M=1
Mi3 inet2 g inet3 b p W=180n L=40n M=1
Mi2 inet1 g inet2 b p W=180n L=40n M=1
Mi1 d g inet1 b p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    p_s_pcell_118
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__p_s_pcell_118 d g s b
* .PININFO b:B d:B g:B s:B
Mi4 inet3 g s b p W=360n L=40n M=1
Mi3 inet2 g inet3 b p W=360n L=40n M=1
Mi2 inet1 g inet2 b p W=360n L=40n M=1
Mi1 d g inet1 b p W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no3_pcell_117
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no3_pcell_117 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqnc o c vssxx vssxx nlp W=90n L=40n M=1
Mqnb o b vssxx vssxx nlp W=90n L=40n M=1
Mqna o a vssxx vssxx nlp W=90n L=40n M=1
Mqpc n1 c vccxx vccxx plp W=90n L=40n M=1
Mqpb n2 b n1 vccxx plp W=90n L=40n M=1
Mqpa o a n2 vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vcorostage_lj
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vcorostage_lj ro cb[2] cb[1] cb[0] ri vccvco vssx
* .PININFO cb[2]:I cb[1]:I cb[0]:I ri:I vccvco:I vssx:I ro:O
Mmp0[8] ro ri vccvco vccvco p W=180n L=40n M=8
Mmp0[7] ro ri vccvco vccvco p W=180n L=40n M=8
Mmp0[6] ro ri vccvco vccvco p W=180n L=40n M=8
Mmp0[5] ro ri vccvco vccvco p W=180n L=40n M=8
Mmp0[4] ro ri vccvco vccvco p W=180n L=40n M=8
Mmp0[3] ro ri vccvco vccvco p W=180n L=40n M=8
Mmp0[2] ro ri vccvco vccvco p W=180n L=40n M=8
Mmp0[1] ro ri vccvco vccvco p W=180n L=40n M=8
Mmn2[8] sw0 cb[0] ro vssx nlvt W=180n L=40n M=2
Mmn2[7] sw0 cb[0] ro vssx nlvt W=180n L=40n M=2
Mmn2[6] sw0 cb[0] ro vssx nlvt W=180n L=40n M=2
Mmn2[5] sw0 cb[0] ro vssx nlvt W=180n L=40n M=2
Mmn2[4] sw0 cb[0] ro vssx nlvt W=180n L=40n M=2
Mmn2[3] sw0 cb[0] ro vssx nlvt W=180n L=40n M=2
Mmn2[2] sw0 cb[0] ro vssx nlvt W=180n L=40n M=2
Mmn2[1] sw0 cb[0] ro vssx nlvt W=180n L=40n M=2
Mmn4[8] sw2 cb[2] ro vssx nlvt W=180n L=40n M=2
Mmn4[7] sw2 cb[2] ro vssx nlvt W=180n L=40n M=2
Mmn4[6] sw2 cb[2] ro vssx nlvt W=180n L=40n M=2
Mmn4[5] sw2 cb[2] ro vssx nlvt W=180n L=40n M=2
Mmn4[4] sw2 cb[2] ro vssx nlvt W=180n L=40n M=2
Mmn4[3] sw2 cb[2] ro vssx nlvt W=180n L=40n M=2
Mmn4[2] sw2 cb[2] ro vssx nlvt W=180n L=40n M=2
Mmn4[1] sw2 cb[2] ro vssx nlvt W=180n L=40n M=2
Mmn3[8] sw1 cb[1] ro vssx nlvt W=180n L=40n M=2
Mmn3[7] sw1 cb[1] ro vssx nlvt W=180n L=40n M=2
Mmn3[6] sw1 cb[1] ro vssx nlvt W=180n L=40n M=2
Mmn3[5] sw1 cb[1] ro vssx nlvt W=180n L=40n M=2
Mmn3[4] sw1 cb[1] ro vssx nlvt W=180n L=40n M=2
Mmn3[3] sw1 cb[1] ro vssx nlvt W=180n L=40n M=2
Mmn3[2] sw1 cb[1] ro vssx nlvt W=180n L=40n M=2
Mmn3[1] sw1 cb[1] ro vssx nlvt W=180n L=40n M=2
Mmp3[8] vccvco sw1 vccvco vccvco plvt W=360n L=40n M=2
Mmp3[7] vccvco sw1 vccvco vccvco plvt W=360n L=40n M=2
Mmp3[6] vccvco sw1 vccvco vccvco plvt W=360n L=40n M=2
Mmp3[5] vccvco sw1 vccvco vccvco plvt W=360n L=40n M=2
Mmp3[4] vccvco sw1 vccvco vccvco plvt W=360n L=40n M=2
Mmp3[3] vccvco sw1 vccvco vccvco plvt W=360n L=40n M=2
Mmp3[2] vccvco sw1 vccvco vccvco plvt W=360n L=40n M=2
Mmp3[1] vccvco sw1 vccvco vccvco plvt W=360n L=40n M=2
Mmp4[8] vccvco sw2 vccvco vccvco plvt W=360n L=40n M=2
Mmp4[7] vccvco sw2 vccvco vccvco plvt W=360n L=40n M=2
Mmp4[6] vccvco sw2 vccvco vccvco plvt W=360n L=40n M=2
Mmp4[5] vccvco sw2 vccvco vccvco plvt W=360n L=40n M=2
Mmp4[4] vccvco sw2 vccvco vccvco plvt W=360n L=40n M=2
Mmp4[3] vccvco sw2 vccvco vccvco plvt W=360n L=40n M=2
Mmp4[2] vccvco sw2 vccvco vccvco plvt W=360n L=40n M=2
Mmp4[1] vccvco sw2 vccvco vccvco plvt W=360n L=40n M=2
Mmp2[8] vccvco sw0 vccvco vccvco plvt W=360n L=40n M=2
Mmp2[7] vccvco sw0 vccvco vccvco plvt W=360n L=40n M=2
Mmp2[6] vccvco sw0 vccvco vccvco plvt W=360n L=40n M=2
Mmp2[5] vccvco sw0 vccvco vccvco plvt W=360n L=40n M=2
Mmp2[4] vccvco sw0 vccvco vccvco plvt W=360n L=40n M=2
Mmp2[3] vccvco sw0 vccvco vccvco plvt W=360n L=40n M=2
Mmp2[2] vccvco sw0 vccvco vccvco plvt W=360n L=40n M=2
Mmp2[1] vccvco sw0 vccvco vccvco plvt W=360n L=40n M=2
Mmn0[8] ro ri vssx vssx n W=180n L=40n M=8
Mmn0[7] ro ri vssx vssx n W=180n L=40n M=8
Mmn0[6] ro ri vssx vssx n W=180n L=40n M=8
Mmn0[5] ro ri vssx vssx n W=180n L=40n M=8
Mmn0[4] ro ri vssx vssx n W=180n L=40n M=8
Mmn0[3] ro ri vssx vssx n W=180n L=40n M=8
Mmn0[2] ro ri vssx vssx n W=180n L=40n M=8
Mmn0[1] ro ri vssx vssx n W=180n L=40n M=8
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_b15nor042xn1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_b15nor042xn1n04x5 o1 vccx vssx a b
* .PININFO a:I b:I o1:O vccx:B vssx:B
Mmp1 o1 a n1 vccx p W=315n L=40n M=1
Mmp0 n1 b vccx vccx p W=315n L=40n M=1
Mmn1 o1 b vssx vssx n W=180n L=40n M=1
Mmn0 o1 a vssx vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nand02al1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02al1n12x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=360n L=40n M=1
Mqp1 o1 a vcc vcc plp W=360n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=540n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=540n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_116
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_116 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=180n L=40n M=1
Mqpa o a vccxx vccxx p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv000an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000an1n03x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=135n L=40n M=1
Mqn1 o1 a vssx vssx n W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    td_pcell_115
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__td_pcell_115 ck ckb d o vccxx vssxx
* .PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqnck o ck n2 vssxx n W=90n L=40n M=1
Mqnd n2 d vssxx vssxx n W=90n L=40n M=1
Mqpckb o ckb n1 vccxx p W=90n L=40n M=1
Mqpd n1 d vccxx vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_114
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_114 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=360n L=40n M=1
Mqpa o a vccxx vccxx p W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_113
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_113 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=90n L=40n M=1
Mqpa o a vccxx vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_112
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_112 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx n W=90n L=40n M=1
Mqpsb o sb i vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_111
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_111 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx n W=135n L=40n M=1
Mqpsb o sb i vccxx p W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_110
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_110 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx n W=270n L=40n M=1
Mqnb n1 b vssxx vssxx n W=270n L=40n M=1
Mqpb o b vccxx vccxx p W=225n L=40n M=1
Mqpa o a vccxx vccxx p W=225n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_109
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_109 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx n W=90n L=40n M=1
Mqnb n1 b vssxx vssxx n W=90n L=40n M=1
Mqpb o b vccxx vccxx p W=135n L=40n M=1
Mqpa o a vccxx vccxx p W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv000an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000an1n04x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=180n L=40n M=1
Mqn1 o1 a vssx vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_b15nand22xn1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_b15nand22xn1n08x5 o1 vccx vssx a b
* .PININFO a:I b:I o1:O vccx:B vssx:B
Mmn2 o1 a n1 vssx n W=180n L=40n M=1
Mmn1 o1 a n1 vssx n W=225n L=40n M=1
Mmn0 n1 b vssx vssx n W=360n L=40n M=1
Mmp0 o1 a vccx vccx p W=315n L=40n M=1
Mmp1 o1 b vccx vccx p W=315n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_108
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_108 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=270n L=40n M=1
Mqpa o a vccxx vccxx p W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_107
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_107 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=180n L=40n M=1
Mqpa o a vccxx vccxx p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_106
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_106 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx n W=360n L=40n M=1
Mqpsb o sb i vccxx p W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    nlp_s_pcell_104
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__nlp_s_pcell_104 d g s b
* .PININFO b:B d:B g:B s:B
Mi1 d g inet1 b nlp W=90n L=40n M=1
Mi2 inet1 g inet2 b nlp W=90n L=40n M=1
Mi3 inet2 g inet3 b nlp W=90n L=40n M=1
Mi4 inet3 g inet4 b nlp W=90n L=40n M=1
Mi5 inet4 g inet5 b nlp W=90n L=40n M=1
Mi6 inet5 g inet6 b nlp W=90n L=40n M=1
Mi7 inet6 g inet7 b nlp W=90n L=40n M=1
Mi8 inet7 g inet8 b nlp W=90n L=40n M=1
Mi9 inet8 g inet9 b nlp W=90n L=40n M=1
Mi10 inet9 g inet10 b nlp W=90n L=40n M=1
Mi11 inet10 g inet11 b nlp W=90n L=40n M=1
Mi12 inet11 g inet12 b nlp W=90n L=40n M=1
Mi13 inet12 g inet13 b nlp W=90n L=40n M=1
Mi14 inet13 g inet14 b nlp W=90n L=40n M=1
Mi15 inet14 g inet15 b nlp W=90n L=40n M=1
Mi16 inet15 g s b nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljiref_pdrv
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljiref_pdrv d enb g vccxx
* .PININFO enb:I g:I vccxx:I d:B
Mmp0 nn1 g vccxx vccxx p W=135n L=40n M=1
Mmp2 n3 g nn2 vccxx p W=135n L=40n M=1
Mmp4 nn5 g nn4 vccxx p W=135n L=40n M=1
Mmp7 nn52 g nn42 vccxx p W=135n L=40n M=1
Mmp14 d vccxx psw2 vccxx p W=135n L=40n M=1
Mmp3 nn4 g n3 vccxx p W=135n L=40n M=1
Mmp5 psw1 g nn5 vccxx p W=135n L=40n M=1
Mmp6 psw2 g nn52 vccxx p W=135n L=40n M=1
Mmp11 nn12 g vccxx vccxx p W=135n L=40n M=1
Mmp12 d enb psw1 vccxx p W=135n L=40n M=1
Mmp8 nn42 g n32 vccxx p W=135n L=40n M=1
Mmp9 n32 g nn22 vccxx p W=135n L=40n M=1
Mmp10 nn22 g nn12 vccxx p W=135n L=40n M=1
Mmp1 nn2 g nn1 vccxx p W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oai012al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oai012al1n03x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp3 n2 c vcc vcc plp W=135n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqp2 o1 b n2 vcc plp W=135n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=135n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=135n L=40n M=1
Mqn3 n1 c vssx vssx nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nand02al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02al1n03x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=90n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=135n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor004al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor004al1n02x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=135n L=40n M=1
Mqp2 n1 b n2 vcc plp W=135n L=40n M=1
Mqp3 n2 c n3 vcc plp W=135n L=40n M=1
Mqp4 n3 d vcc vcc plp W=135n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
Mqn3 o1 c vssx vssx nlp W=90n L=40n M=1
Mqn4 o1 d vssx vssx nlp W=90n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_tgate_ll_anamux
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_tgate_ll_anamux io1 io2 en en_b vccxx vssx
* .PININFO en:I en_b:I vccxx:I vssx:I io1:B io2:B
Mqn1[4] n0 en io1 vssx ntgmv W=180n L=120n M=1
Mqn1[3] n0 en io1 vssx ntgmv W=180n L=120n M=1
Mqn1[2] n0 en io1 vssx ntgmv W=180n L=120n M=1
Mqn1[1] n0 en io1 vssx ntgmv W=180n L=120n M=1
Mqn2[4] io2 en n0 vssx ntgmv W=180n L=120n M=1
Mqn2[3] io2 en n0 vssx ntgmv W=180n L=120n M=1
Mqn2[2] io2 en n0 vssx ntgmv W=180n L=120n M=1
Mqn2[1] io2 en n0 vssx ntgmv W=180n L=120n M=1
Mqp2[4] io2 en_b n1 vccxx ptgmv W=180n L=120n M=1
Mqp2[3] io2 en_b n1 vccxx ptgmv W=180n L=120n M=1
Mqp2[2] io2 en_b n1 vccxx ptgmv W=180n L=120n M=1
Mqp2[1] io2 en_b n1 vccxx ptgmv W=180n L=120n M=1
Mqp1[4] n1 en_b io1 vccxx ptgmv W=180n L=120n M=1
Mqp1[3] n1 en_b io1 vccxx ptgmv W=180n L=120n M=1
Mqp1[2] n1 en_b io1 vccxx ptgmv W=180n L=120n M=1
Mqp1[1] n1 en_b io1 vccxx ptgmv W=180n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljpll_tgate
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljpll_tgate io1 io2 vccxx en en_b vssx
* .PININFO en:I en_b:I vssx:I io1:B io2:B vccxx:B
Mmp1[4] io2 en_b n1 vccxx p W=180n L=40n M=1
Mmp1[3] io2 en_b n1 vccxx p W=180n L=40n M=1
Mmp1[2] io2 en_b n1 vccxx p W=180n L=40n M=1
Mmp1[1] io2 en_b n1 vccxx p W=180n L=40n M=1
Mmp0[4] n1 en_b io1 vccxx p W=180n L=40n M=1
Mmp0[3] n1 en_b io1 vccxx p W=180n L=40n M=1
Mmp0[2] n1 en_b io1 vccxx p W=180n L=40n M=1
Mmp0[1] n1 en_b io1 vccxx p W=180n L=40n M=1
Mmn1[4] io2 en n0 vssx n W=180n L=40n M=1
Mmn1[3] io2 en n0 vssx n W=180n L=40n M=1
Mmn1[2] io2 en n0 vssx n W=180n L=40n M=1
Mmn1[1] io2 en n0 vssx n W=180n L=40n M=1
Mmn0[4] n0 en io1 vssx n W=180n L=40n M=1
Mmn0[3] n0 en io1 vssx n W=180n L=40n M=1
Mmn0[2] n0 en io1 vssx n W=180n L=40n M=1
Mmn0[1] n0 en io1 vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_b15nand24xn1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_b15nand24xn1n08x5 o1 vccx vssx a b c d
* .PININFO a:I b:I c:I d:I o1:O vccx:B vssx:B
Mmp0 o1 a vccx vccx p W=270n L=40n M=1
Mmp3 o1 d vccx vccx p W=270n L=40n M=1
Mmp2 o1 c vccx vccx p W=270n L=40n M=1
Mmp1 o1 b vccx vccx p W=270n L=40n M=1
Mmn1 n1 b n2 vssx n W=360n L=40n M=1
Mmn2 n2 c n3 vssx n W=360n L=40n M=1
Mmn3 n3 d vssx vssx n W=360n L=40n M=1
Mmn0 o1 a n1 vssx n W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv000an1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000an1n05x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=225n L=40n M=1
Mqn1 o1 a vssx vssx n W=225n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv000an1n32x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000an1n32x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=1.44u L=40n M=1
Mqn1 o1 a vssx vssx n W=1.44u L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor002al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002al1n02x3 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=90n L=40n M=1
Mqp2 n1 b vcc vcc plp W=90n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    nlp_s_pcell_101
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__nlp_s_pcell_101 d g s b
* .PININFO b:B d:B g:B s:B
Mi1 d g inet1 b nlp W=135n L=40n M=1
Mi2 inet1 g inet2 b nlp W=135n L=40n M=1
Mi3 inet2 g inet3 b nlp W=135n L=40n M=1
Mi4 inet3 g inet4 b nlp W=135n L=40n M=1
Mi5 inet4 g inet5 b nlp W=135n L=40n M=1
Mi6 inet5 g inet6 b nlp W=135n L=40n M=1
Mi7 inet6 g inet7 b nlp W=135n L=40n M=1
Mi8 inet7 g inet8 b nlp W=135n L=40n M=1
Mi9 inet8 g inet9 b nlp W=135n L=40n M=1
Mi10 inet9 g inet10 b nlp W=135n L=40n M=1
Mi11 inet10 g inet11 b nlp W=135n L=40n M=1
Mi12 inet11 g inet12 b nlp W=135n L=40n M=1
Mi13 inet12 g inet13 b nlp W=135n L=40n M=1
Mi14 inet13 g inet14 b nlp W=135n L=40n M=1
Mi15 inet14 g inet15 b nlp W=135n L=40n M=1
Mi16 inet15 g s b nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor002al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002al1n04x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=270n L=40n M=1
Mqp2 n1 b vcc vcc plp W=270n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=180n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na3_pcell_99
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na3_pcell_99 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlp W=180n L=40n M=1
Mqnb n1 b n2 vssxx nlp W=180n L=40n M=1
Mqnc n2 c vssxx vssxx nlp W=180n L=40n M=1
Mqpc o c vccxx vccxx plp W=135n L=40n M=1
Mqpb o b vccxx vccxx plp W=135n L=40n M=1
Mqpa o a vccxx vccxx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nand03al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand03al1n02x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=90n L=40n M=1
Mqp3 o1 c vcc vcc plp W=90n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=90n L=40n M=1
Mqn2 n1 b n2 vssx nlp W=90n L=40n M=1
Mqn3 n2 c vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor003al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor003al1n04x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 n1 b n2 vcc plp W=270n L=40n M=1
Mqp3 n2 c vcc vcc plp W=270n L=40n M=1
Mqp1 o1 a n1 vcc plp W=270n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=180n L=40n M=1
Mqn3 o1 c vssx vssx nlp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    td_pcell_98
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__td_pcell_98 ck ckb d o vccxx vssxx
* .PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqnck o ck n2 vssxx n W=90n L=40n M=1
Mqnd n2 d vssxx vssxx n W=90n L=40n M=1
Mqpckb o ckb n1 vccxx p W=90n L=40n M=1
Mqpd n1 d vccxx vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_97
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_97 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=90n L=40n M=1
Mqpa o a vccxx vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_96
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_96 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx n W=90n L=40n M=1
Mqpsb o sb i vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_95
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_95 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx n W=135n L=40n M=1
Mqnb n1 b vssxx vssxx n W=135n L=40n M=1
Mqpb o b vccxx vccxx p W=90n L=40n M=1
Mqpa o a vccxx vccxx p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nand02al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02al1n02x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=90n L=40n M=1
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: gd
*  Cell Name:    b15sg00d0ag1d02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15sg00d0ag1d02x5 force0_ehv in0_ehv out0_ehv vcc_in_ehv vcc_out_ehv vssx m=1
* .PININFO force0_ehv:I in0_ehv:I out0_ehv:O vcc_in_ehv:B vcc_out_ehv:B vssx:B
Mqn8 out0_ehv force0_ehv vssx vssx ntg W=135n L=160n M=1
Mqn3 n3 n1 vssx vssx ntg W=270n L=160n M=1
Mqn4 n3 n2 vssx vssx ntg W=90n L=160n M=1
Mqn1 n2 in0_ehv vssx vssx ntg W=270n L=160n M=1
Mqn5 out0_ehv n1 vssx vssx ntg W=270n L=160n M=1
Mqn0 n1 in0_ehv vssx vssx ntg W=270n L=160n M=1
Mqn6 out0_ehv n2 vssx vssx ntg W=90n L=160n M=1
Mqn2 n2 n3 vssx vssx ntg W=90n L=160n M=1
Mqn7 in0_ehv vssx vssx vssx ntg W=90n L=160n M=1
Mqn9 force0_ehv vssx vssx vssx ntg W=90n L=160n M=1
Mqp9 n7 force0_ehv vcc_out_ehv vcc_out_ehv ptg W=360n L=160n M=1
Mqp5 out0_ehv n2 n7 vcc_out_ehv ptg W=270n L=160n M=1
Mqp4 n5 n2 n6 vcc_out_ehv ptg W=135n L=160n M=1
Mqp3 n3 n1 n5 vcc_out_ehv ptg W=135n L=160n M=1
Mqp2 n4 n3 n6 vcc_out_ehv ptg W=135n L=160n M=1
Mqp0 n1 in0_ehv vcc_in_ehv vcc_in_ehv ptg W=270n L=160n M=1
Mqp1 n2 in0_ehv n4 vcc_out_ehv ptg W=135n L=160n M=1
Mqp8 n6 force0_ehv vcc_out_ehv vcc_out_ehv ptg W=180n L=160n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_92
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_92 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx ntg W=270n L=160n M=1
Mqpa o a vccxx vccxx ptg W=270n L=160n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_91
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_91 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx ntg W=90n L=160n M=1
Mqpa o a vccxx vccxx ptg W=90n L=160n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_90
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_90 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx ntg W=180n L=160n M=1
Mqpsb o sb i vccxx ptg W=180n L=160n M=1
.ENDS

* ***********************************************************************
*  Library Name: gd
*  Cell Name:    b15inv000ag1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000ag1n04x5 a_ehv o1_ehv vcc_ehv vssx m=1
* .PININFO a_ehv:I o1_ehv:O vcc_ehv:B vssx:B
Mqn1 o1_ehv a_ehv vssx vssx ntg W=180n L=160n M=1
Mqp1 o1_ehv a_ehv vcc_ehv vcc_ehv ptg W=180n L=160n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    n_s_pcell_89
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__n_s_pcell_89 d g s b
* .PININFO b:B d:B g:B s:B
Mi1 d g inet1 b n W=90n L=40n M=1
Mi2 inet1 g inet2 b n W=90n L=40n M=1
Mi3 inet2 g inet3 b n W=90n L=40n M=1
Mi4 inet3 g s b n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    p_s_pcell_88
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__p_s_pcell_88 d g s b
* .PININFO b:B d:B g:B s:B
Mi4 inet3 g s b p W=90n L=40n M=1
Mi3 inet2 g inet3 b p W=90n L=40n M=1
Mi2 inet1 g inet2 b p W=90n L=40n M=1
Mi1 d g inet1 b p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    p_s_pcell_87
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__p_s_pcell_87 d g s b
* .PININFO b:B d:B g:B s:B
Mi4 inet3 g s b p W=180n L=40n M=1
Mi3 inet2 g inet3 b p W=180n L=40n M=1
Mi2 inet1 g inet2 b p W=180n L=40n M=1
Mi1 d g inet1 b p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22prim
*  Cell Name:    n_s_pcell_86
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__n_s_pcell_86 d g s b
* .PININFO b:B d:B g:B s:B
Mi1 d g inet1 b n W=180n L=40n M=1
Mi2 inet1 g inet2 b n W=180n L=40n M=1
Mi3 inet2 g inet3 b n W=180n L=40n M=1
Mi4 inet3 g s b n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na3_pcell_85
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na3_pcell_85 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlp W=135n L=40n M=1
Mqnb n1 b n2 vssxx nlp W=135n L=40n M=1
Mqnc n2 c vssxx vssxx nlp W=135n L=40n M=1
Mqpc o c vccxx vccxx plp W=90n L=40n M=1
Mqpb o b vccxx vccxx plp W=90n L=40n M=1
Mqpa o a vccxx vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na3_pcell_84
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na3_pcell_84 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlp W=90n L=40n M=1
Mqnb n1 b n2 vssxx nlp W=90n L=40n M=1
Mqnc n2 c vssxx vssxx nlp W=90n L=40n M=1
Mqpc o c vccxx vccxx plp W=90n L=40n M=1
Mqpb o b vccxx vccxx plp W=90n L=40n M=1
Mqpa o a vccxx vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_83
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_83 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=360n L=40n M=2
Mqpa o a vccxx vccxx plp W=270n L=40n M=3
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_82
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_82 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlp W=270n L=40n M=1
Mqnb n1 b vssxx vssxx nlp W=270n L=40n M=1
Mqpb o b vccxx vccxx plp W=180n L=40n M=1
Mqpa o a vccxx vccxx plp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_81
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_81 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlp W=270n L=40n M=2
Mqnb n1 b vssxx vssxx nlp W=270n L=40n M=2
Mqpb o b vccxx vccxx plp W=360n L=40n M=1
Mqpa o a vccxx vccxx plp W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    b2a2no2_pcell_80
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b2a2no2_pcell_80 a b c d o vccxx vssxx
* .PININFO a:I b:I c:I d:I o:O vccxx:B vssxx:B
Mqnb n3 b vssxx vssxx nlp W=360n L=40n M=1
Mqna o a n3 vssxx nlp W=360n L=40n M=1
Mqnc o c n2 vssxx nlp W=360n L=40n M=1
Mqnd n2 d vssxx vssxx nlp W=360n L=40n M=1
Mqpa o a n0 vccxx plp W=360n L=40n M=1
Mqpb o b n0 vccxx plp W=360n L=40n M=1
Mqpc n0 c vccxx vccxx plp W=360n L=40n M=1
Mqpd n0 d vccxx vccxx plp W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15csb0ndal1d16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15csb0ndal1d16x5 clk clkout vcc_in vcc_out vssx m=1
* .PININFO clk:I clkout:O vcc_in:B vcc_out:B vssx:B
Mqp10 n9 n8 vcc_out vcc_out plp W=270n L=40n M=1
Mqp5 n8 n2 vcc_out vcc_out plp W=270n L=40n M=1
Mqp4 n5 n2 vcc_out vcc_out plp W=135n L=40n M=1
Mqp3 n3 n1 n5 vcc_out plp W=135n L=40n M=1
Mqp2 n4 n3 vcc_out vcc_out plp W=135n L=40n M=1
Mqp0 n1 clk vcc_in vcc_in plp W=270n L=40n M=1
Mqp1 n2 clk n4 vcc_out plp W=135n L=40n M=1
Mqp11 clkout n9 vcc_out vcc_out plp W=720n L=40n M=1
Mqn3 n3 n1 vssx vssx nlp W=405n L=40n M=1
Mqn7 clk vssx vssx vssx nlp W=90n L=40n M=1
Mqn5 n8 n1 vssx vssx nlp W=270n L=40n M=1
Mqn0 n1 clk vssx vssx nlp W=270n L=40n M=1
Mqn6 n8 n2 vssx vssx nlp W=90n L=40n M=1
Mqn11 clkout n9 vssx vssx nlp W=720n L=40n M=1
Mqn10 n9 n8 vssx vssx nlp W=135n L=40n M=1
Mqn1 n2 clk vssx vssx nlp W=405n L=40n M=1
Mqn2 n2 n3 vssx vssx nlp W=90n L=40n M=1
Mqn4 n3 n2 vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_77
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_77 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=360n L=40n M=3
Mqpa o a vccxx vccxx plvt W=360n L=40n M=3
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n24x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n24x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=1.08u L=40n M=1
Mqn1 o1 a vssx vssx nlp W=1.08u L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no2_pcell_76
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no2_pcell_76 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=90n L=40n M=1
Mqnb o b vssxx vssxx nlp W=90n L=40n M=1
Mqpb n1 b vccxx vccxx plp W=135n L=40n M=1
Mqpa o a n1 vccxx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cinv00ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cinv00ah1n04x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 clkout clk vcc vcc plvt W=180n L=40n M=1
Mqn1 clkout clk vssx vssx nlvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15sg00d0bl1d04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15sg00d0bl1d04x5 force0 in0 out0 vcc_in vcc_out vssx m=1
* .PININFO force0:I in0:I out0:O vcc_in:B vcc_out:B vssx:B
Mqp9 n7 force0 vcc_out vcc_out plp W=720n L=40n M=1
Mqp5 out0 n2 n7 vcc_out plp W=540n L=40n M=1
Mqp4 n5 n2 n6 vcc_out plp W=270n L=40n M=1
Mqp3 n3 n1 n5 vcc_out plp W=270n L=40n M=1
Mqp2 n4 n3 n6 vcc_out plp W=270n L=40n M=1
Mqp0 n1 in0 vcc_in vcc_in plp W=540n L=40n M=1
Mqp1 n2 in0 n4 vcc_out plp W=270n L=40n M=1
Mqp8 n6 force0 vcc_out vcc_out plp W=360n L=40n M=1
Mqn8 out0 force0 vssx vssx nlp W=270n L=40n M=1
Mqn3 n3 n1 vssx vssx nlp W=810n L=40n M=1
Mqn4 n3 n2 vssx vssx nlp W=90n L=40n M=1
Mqn1 n2 in0 vssx vssx nlp W=810n L=40n M=1
Mqn5 out0 n1 vssx vssx nlp W=540n L=40n M=1
Mqn0 n1 in0 vssx vssx nlp W=540n L=40n M=1
Mqn6 out0 n2 vssx vssx nlp W=180n L=40n M=1
Mqn2 n2 n3 vssx vssx nlp W=90n L=40n M=1
Mqn7 in0 vssx vssx vssx nlp W=90n L=40n M=1
Mqn9 force0 vssx vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_75
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_75 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=360n L=40n M=3
Mqpa o a vccxx vccxx plp W=360n L=40n M=3
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15sg00ndal1d04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15sg00ndal1d04x5 in0 out0 vcc_in vcc_out vssx m=1
* .PININFO in0:I out0:O vcc_in:B vcc_out:B vssx:B
Mqp1 n2 in0 n4 vcc_out plp W=270n L=40n M=1
Mqp2 n4 n3 vcc_out vcc_out plp W=270n L=40n M=1
Mqp3 n3 n1 n5 vcc_out plp W=270n L=40n M=1
Mqp4 n5 n2 vcc_out vcc_out plp W=270n L=40n M=1
Mqp5 out0 n2 vcc_out vcc_out plp W=360n L=40n M=1
Mqp0 n1 in0 vcc_in vcc_in plp W=540n L=40n M=1
Mqn0 n1 in0 vssx vssx nlp W=540n L=40n M=1
Mqn1 n2 in0 vssx vssx nlp W=810n L=40n M=1
Mqn2 n2 n3 vssx vssx nlp W=90n L=40n M=1
Mqn4 n3 n2 vssx vssx nlp W=90n L=40n M=1
Mqn3 n3 n1 vssx vssx nlp W=810n L=40n M=1
Mqn5 out0 n1 vssx vssx nlp W=540n L=40n M=1
Mqn6 out0 n2 vssx vssx nlp W=180n L=40n M=1
Mqn7 in0 vssx vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nand02al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02al1n08x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=270n L=40n M=1
Mqp1 o1 a vcc vcc plp W=270n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=360n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor002al1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002al1n06x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=360n L=40n M=1
Mqp2 n1 b vcc vcc plp W=360n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=270n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nandp2ah1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nandp2ah1n08x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plvt W=360n L=40n M=1
Mqp1 o1 a vcc vcc plvt W=360n L=40n M=1
Mqn2 n1 b vssx vssx nlvt W=360n L=40n M=1
Mqn1 o1 a n1 vssx nlvt W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15inv000ah1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000ah1n12x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plvt W=540n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=540n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nor002ah1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002ah1n08x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plvt W=540n L=40n M=1
Mqp2 n1 b vcc vcc plvt W=540n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=360n L=40n M=1
Mqn2 o1 b vssx vssx nlvt W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_74
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_74 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlvt W=360n L=40n M=1
Mqnb n1 b vssxx vssxx nlvt W=360n L=40n M=1
Mqpb o b vccxx vccxx plvt W=270n L=40n M=1
Mqpa o a vccxx vccxx plvt W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nor002ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002ah1n03x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plvt W=180n L=40n M=1
Mqp2 n1 b vcc vcc plvt W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=135n L=40n M=1
Mqn2 o1 b vssx vssx nlvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15inv000ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000ah1n03x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plvt W=135n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nor002ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002ah1n04x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plvt W=270n L=40n M=1
Mqp2 n1 b vcc vcc plvt W=270n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=180n L=40n M=1
Mqn2 o1 b vssx vssx nlvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nand02ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02ah1n04x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plvt W=135n L=40n M=1
Mqp1 o1 a vcc vcc plvt W=135n L=40n M=1
Mqn2 n1 b vssx vssx nlvt W=180n L=40n M=1
Mqn1 o1 a n1 vssx nlvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor002al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002al1n08x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=540n L=40n M=1
Mqp2 n1 b vcc vcc plp W=540n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=360n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nand02ah1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02ah1n08x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plvt W=270n L=40n M=1
Mqp1 o1 a vcc vcc plvt W=270n L=40n M=1
Mqn2 n1 b vssx vssx nlvt W=360n L=40n M=1
Mqn1 o1 a n1 vssx nlvt W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nor002ah1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002ah1n16x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plvt W=1.08u L=40n M=1
Mqp2 n1 b vcc vcc plvt W=1.08u L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=720n L=40n M=1
Mqn2 o1 b vssx vssx nlvt W=720n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nor003ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor003ah1n04x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 n1 b n2 vcc plvt W=270n L=40n M=1
Mqp3 n2 c vcc vcc plvt W=270n L=40n M=1
Mqp1 o1 a n1 vcc plvt W=270n L=40n M=1
Mqn2 o1 b vssx vssx nlvt W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=180n L=40n M=1
Mqn3 o1 c vssx vssx nlvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15aoi012ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi012ah1n04x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp3 n1 c vcc vcc plvt W=270n L=40n M=1
Mqp2 n1 b vcc vcc plvt W=270n L=40n M=1
Mqp1 o1 a n1 vcc plvt W=270n L=40n M=1
Mqn3 n2 c vssx vssx nlvt W=270n L=40n M=1
Mqn2 o1 b n2 vssx nlvt W=270n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor002al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002al1n03x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=180n L=40n M=1
Mqp2 n1 b vcc vcc plp W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=135n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15inv000ah1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000ah1n06x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plvt W=270n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_73
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_73 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlvt W=135n L=40n M=1
Mqpsb o sb i vccxx plvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nand03ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand03ah1n03x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plvt W=90n L=40n M=1
Mqp3 o1 c vcc vcc plvt W=90n L=40n M=1
Mqp1 o1 a vcc vcc plvt W=90n L=40n M=1
Mqn1 o1 a n1 vssx nlvt W=135n L=40n M=1
Mqn2 n1 b n2 vssx nlvt W=135n L=40n M=1
Mqn3 n2 c vssx vssx nlvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_72
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_72 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlp W=360n L=40n M=1
Mqpsb o sb i vccxx plp W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_71
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_71 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=360n L=40n M=2
Mqpa o a vccxx vccxx plp W=360n L=40n M=2
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_70
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_70 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlvt W=180n L=40n M=1
Mqpsb o sb i vccxx plvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_69
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_69 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=180n L=40n M=1
Mqpa o a vccxx vccxx plvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_68
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_68 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=135n L=40n M=1
Mqpa o a vccxx vccxx plvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    td_pcell_67
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__td_pcell_67 ck ckb d o vccxx vssxx
* .PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqnck o ck n2 vssxx nlvt W=90n L=40n M=1
Mqnd n2 d vssxx vssxx nlvt W=90n L=40n M=1
Mqpckb o ckb n1 vccxx plvt W=90n L=40n M=1
Mqpd n1 d vccxx vccxx plvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_66
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_66 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlvt W=90n L=40n M=1
Mqpsb o sb i vccxx plvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nor003ah1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor003ah1n08x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 n1 b n2 vcc plvt W=540n L=40n M=1
Mqp3 n2 c vcc vcc plvt W=540n L=40n M=1
Mqp1 o1 a n1 vcc plvt W=540n L=40n M=1
Mqn2 o1 b vssx vssx nlvt W=360n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=360n L=40n M=1
Mqn3 o1 c vssx vssx nlvt W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n16x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=720n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=720n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15aoi112ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi112ah1n03x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp1 n2 d vcc vcc plvt W=270n L=40n M=1
Mqp2 n2 c vcc vcc plvt W=270n L=40n M=1
Mqp3 n3 b n2 vcc plvt W=270n L=40n M=1
Mqp4 o1 a n3 vcc plvt W=270n L=40n M=1
Mqn3 o1 b vssx vssx nlvt W=135n L=40n M=1
Mqn2 o1 c n0 vssx nlvt W=180n L=40n M=1
Mqn1 n0 d vssx vssx nlvt W=180n L=40n M=1
Mqn4 o1 a vssx vssx nlvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15inv000ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000ah1n04x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plvt W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15aoi013ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoi013ah1n03x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp3 n1 c vcc vcc plvt W=180n L=40n M=1
Mqp4 n1 d vcc vcc plvt W=180n L=40n M=1
Mqp1 o1 a n1 vcc plvt W=180n L=40n M=1
Mqp2 n1 b vcc vcc plvt W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=135n L=40n M=1
Mqn2 o1 b n2 vssx nlvt W=270n L=40n M=1
Mqn3 n2 c n3 vssx nlvt W=270n L=40n M=1
Mqn4 n3 d vssx vssx nlvt W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_65
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_65 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlvt W=225n L=40n M=1
Mqpsb o sb i vccxx plvt W=225n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15inv000ah1n20x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000ah1n20x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plvt W=900n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=900n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15inv000ah1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000ah1n16x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plvt W=720n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=720n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_divkon02
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_divkon02 o1 a b c vccxx vssx
* .PININFO a:I b:I c:I vccxx:I vssx:I o1:O
Mmn4 o1 a net19 vssx nlvt W=90n L=40n M=1
Mmn3 o1 c net17 vssx nlvt W=90n L=40n M=1
Mmn2 net19 b vssx vssx nlvt W=90n L=40n M=1
Mmn1 net17 a vssx vssx nlvt W=90n L=40n M=1
Mmn0 net17 b vssx vssx nlvt W=90n L=40n M=1
Mmp4 o1 a net18 vccxx plvt W=90n L=40n M=1
Mmp3 o1 c net16 vccxx plvt W=90n L=40n M=1
Mmp2 net18 b vccxx vccxx plvt W=90n L=40n M=1
Mmp1 net16 a vccxx vccxx plvt W=90n L=40n M=1
Mmp0 net16 b vccxx vccxx plvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15aoai13ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aoai13ah1n03x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp1 n1 c vcc vcc plvt W=135n L=40n M=1
Mqp3 o1 b n1 vcc plvt W=135n L=40n M=1
Mqp2 n1 d vcc vcc plvt W=135n L=40n M=1
Mqp4 o1 a vcc vcc plvt W=135n L=40n M=1
Mqn4 n3 d vssx vssx nlvt W=270n L=40n M=1
Mqn2 n2 b vssx vssx nlvt W=135n L=40n M=1
Mqn1 o1 a n2 vssx nlvt W=135n L=40n M=1
Mqn3 n2 c n3 vssx nlvt W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nor003ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor003ah1n03x5 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 n1 b n2 vcc plvt W=180n L=40n M=1
Mqp3 n2 c vcc vcc plvt W=180n L=40n M=1
Mqp1 o1 a n1 vcc plvt W=180n L=40n M=1
Mqn2 o1 b vssx vssx nlvt W=135n L=40n M=1
Mqn1 o1 a vssx vssx nlvt W=135n L=40n M=1
Mqn3 o1 c vssx vssx nlvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    td_pcell_64
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__td_pcell_64 ck ckb d o vccxx vssxx
* .PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqnck o ck n2 vssxx nlp W=270n L=40n M=1
Mqnd n2 d vssxx vssxx nlp W=270n L=40n M=1
Mqpckb o ckb n1 vccxx plp W=270n L=40n M=1
Mqpd n1 d vccxx vccxx plp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_63
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_63 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlplvt W=180n L=40n M=1
Mqpa o a vccxx vccxx plplvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_62
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_62 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlplvt W=135n L=40n M=1
Mqpa o a vccxx vccxx plplvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_61
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_61 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlp W=135n L=40n M=1
Mqpsb o sb i vccxx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_60
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_60 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlp W=270n L=40n M=1
Mqpsb o sb i vccxx plp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_59
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_59 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=270n L=40n M=2
Mqpa o a vccxx vccxx plvt W=270n L=40n M=2
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_58
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_58 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlvt W=270n L=40n M=1
Mqpsb o sb i vccxx plvt W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_57
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_57 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=270n L=40n M=1
Mqpa o a vccxx vccxx plvt W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n03x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=135n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor004al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor004al1n04x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=270n L=40n M=1
Mqp2 n1 b n2 vcc plp W=270n L=40n M=1
Mqp3 n2 c n3 vcc plp W=270n L=40n M=1
Mqp4 n3 d vcc vcc plp W=270n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=180n L=40n M=1
Mqn3 o1 c vssx vssx nlp W=180n L=40n M=1
Mqn4 o1 d vssx vssx nlp W=180n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_56
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_56 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlp W=90n L=40n M=1
Mqnb n1 b vssxx vssxx nlp W=90n L=40n M=1
Mqpb o b vccxx vccxx plp W=90n L=40n M=1
Mqpa o a vccxx vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no2_pcell_55
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no2_pcell_55 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=90n L=40n M=1
Mqnb o b vssxx vssxx nlp W=90n L=40n M=1
Mqpb n1 b vccxx vccxx plp W=90n L=40n M=1
Mqpa o a n1 vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n08x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=360n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cinv00ah1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cinv00ah1n08x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 clkout clk vcc vcc plvt W=360n L=40n M=1
Mqn1 clkout clk vssx vssx nlvt W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_53
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_53 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx n W=180n L=40n M=1
Mqpa o a vccxx vccxx p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cinv00ah1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cinv00ah1n12x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 clkout clk vcc vcc plvt W=540n L=40n M=1
Mqn1 clkout clk vssx vssx nlvt W=540n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv000an1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000an1n12x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=540n L=40n M=1
Mqn1 o1 a vssx vssx n W=540n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nor002an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor002an1n03x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc p W=180n L=40n M=1
Mqp2 n1 b vcc vcc p W=180n L=40n M=1
Mqn1 o1 a vssx vssx n W=135n L=40n M=1
Mqn2 o1 b vssx vssx n W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nand02an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02an1n03x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc p W=90n L=40n M=1
Mqp1 o1 a vcc vcc p W=90n L=40n M=1
Mqn2 n1 b vssx vssx n W=135n L=40n M=1
Mqn1 o1 a n1 vssx n W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv000an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000an1n02x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=90n L=40n M=1
Mqn1 o1 a vssx vssx n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv000an1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000an1n06x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=270n L=40n M=1
Mqn1 o1 a vssx vssx n W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv000an1n20x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000an1n20x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=900n L=40n M=1
Mqn1 o1 a vssx vssx n W=900n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_pllcolesoai
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_pllcolesoai ob a b c vccxx vssx
* .PININFO a:I b:I c:I vccxx:I vssx:I ob:O
Mmn2 x0 a vssx vssx nlvt W=90n L=40n M=1
Mmn3 x0 vssx vssx vssx nlvt W=90n L=40n M=1
Mmn0 ob c x0 vssx nlvt W=90n L=40n M=1
Mmn1 ob b x0 vssx nlvt W=90n L=40n M=1
Mmp0 x1 c vccxx vccxx plvt W=135n L=40n M=1
Mmp1 ob b x1 vccxx plvt W=135n L=40n M=1
Mmp2 ob a vccxx vccxx plvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_pllcolesaoi
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_pllcolesaoi ob a b c vccxx vssx
* .PININFO a:I b:I c:I vccxx:I vssx:I ob:O
Mmn0 ob b x0 vssx nlvt W=90n L=40n M=1
Mmn2 ob a vssx vssx nlvt W=90n L=40n M=1
Mmn1 x0 c vssx vssx nlvt W=90n L=40n M=1
Mmp2 ob b x1 vccxx plvt W=135n L=40n M=1
Mmp3 ob c x1 vccxx plvt W=135n L=40n M=1
Mmp1 x1 a vccxx vccxx plvt W=135n L=40n M=1
Mmp0 x1 vccxx vccxx vccxx plvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cinv00ah1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cinv00ah1n16x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 clkout clk vcc vcc plvt W=810n L=40n M=1
Mqn1 clkout clk vssx vssx nlvt W=720n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nand02al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nand02al1n04x5 a b o1 vcc vssx m=1
* .PININFO a:I b:I o1:O vcc:B vssx:B
Mqp2 o1 b vcc vcc plp W=135n L=40n M=1
Mqp1 o1 a vcc vcc plp W=135n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=180n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor003al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor003al1n02x3 a b c o1 vcc vssx m=1
* .PININFO a:I b:I c:I o1:O vcc:B vssx:B
Mqp2 n1 b n2 vcc plp W=90n L=40n M=1
Mqp3 n2 c vcc vcc plp W=90n L=40n M=1
Mqp1 o1 a n1 vcc plp W=90n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=90n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
Mqn3 o1 c vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_52
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_52 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=360n L=40n M=1
Mqpa o a vccxx vccxx plvt W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_51
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_51 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=90n L=40n M=1
Mqpa o a vccxx vccxx plvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_50
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_50 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlvt W=360n L=40n M=2
Mqpa o a vccxx vccxx plvt W=270n L=40n M=3
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_49
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_49 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlvt W=360n L=40n M=1
Mqpsb o sb i vccxx plvt W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_clknand
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_clknand o1 vccx vssx clk en
* .PININFO clk:I en:I o1:O vccx:B vssx:B
Mqn2 n1 en vssx vssx nlvt W=180n L=40n M=12
Mqn1 o1 clk n1 vssx nlvt W=180n L=40n M=4
Mqp2 o1 en vccx vccx plvt W=90n L=40n M=1
Mqp1 o1 clk vccx vccx plvt W=135n L=40n M=4
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_48
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_48 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlp W=135n L=40n M=1
Mqnb n1 b vssxx vssxx nlp W=135n L=40n M=1
Mqpb o b vccxx vccxx plp W=90n L=40n M=1
Mqpa o a vccxx vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n02x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=90n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_47
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_47 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlp W=180n L=40n M=1
Mqpsb o sb i vccxx plp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_46
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_46 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=135n L=40n M=1
Mqpa o a vccxx vccxx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    td_pcell_45
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__td_pcell_45 ck ckb d o vccxx vssxx
* .PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqnck o ck n2 vssxx nlp W=90n L=40n M=1
Mqnd n2 d vssxx vssxx nlp W=90n L=40n M=1
Mqpckb o ckb n1 vccxx plp W=90n L=40n M=1
Mqpd n1 d vccxx vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_44
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_44 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlplvt W=90n L=40n M=1
Mqpa o a vccxx vccxx plplvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_43
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_43 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=270n L=40n M=1
Mqpa o a vccxx vccxx plp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no2_pcell_42
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no2_pcell_42 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=180n L=40n M=1
Mqnb o b vssxx vssxx nlp W=180n L=40n M=1
Mqpb n1 b vccxx vccxx plp W=270n L=40n M=1
Mqpa o a n1 vccxx plp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_41
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_41 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=360n L=40n M=1
Mqpa o a vccxx vccxx plp W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nor004al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nor004al1n03x5 a b c d o1 vcc vssx m=1
* .PININFO a:I b:I c:I d:I o1:O vcc:B vssx:B
Mqp1 o1 a n1 vcc plp W=180n L=40n M=1
Mqp2 n1 b n2 vcc plp W=180n L=40n M=1
Mqp3 n2 c n3 vcc plp W=180n L=40n M=1
Mqp4 n3 d vcc vcc plp W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=135n L=40n M=1
Mqn3 o1 c vssx vssx nlp W=135n L=40n M=1
Mqn4 o1 d vssx vssx nlp W=135n L=40n M=1
Mqn2 o1 b vssx vssx nlp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n06x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=270n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no2_pcell_39
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no2_pcell_39 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=135n L=40n M=1
Mqnb o b vssxx vssxx nlp W=135n L=40n M=1
Mqpb n1 b vccxx vccxx plp W=180n L=40n M=1
Mqpa o a n1 vccxx plp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15inv000an1n10x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000an1n10x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc p W=450n L=40n M=1
Mqn1 o1 a vssx vssx n W=450n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15tihi00an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15tihi00an1n03x5 o vcc vssx m=1
* .PININFO o:O vcc:B vssx:B
Mqp1 o vssx vcc vcc p W=90n L=40n M=1
Mqn1 o vssx vssx vssx n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: gd
*  Cell Name:    b15tihi00ag1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15tihi00ag1n03x5 o_ehv vcc_ehv vssx m=1
* .PININFO o_ehv:O vcc_ehv:B vssx:B
Mqn1 o_ehv vssx vssx vssx ntg W=180n L=160n M=1
Mqp1 o_ehv vssx vcc_ehv vcc_ehv ptg W=180n L=160n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_38
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_38 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=90n L=40n M=1
Mqpa o a vccxx vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_37
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_37 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlp W=90n L=40n M=1
Mqpsb o sb i vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_36
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_36 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=180n L=40n M=1
Mqpa o a vccxx vccxx plp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_35
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_35 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlp W=180n L=40n M=1
Mqnb n1 b vssxx vssxx nlp W=180n L=40n M=1
Mqpb o b vccxx vccxx plp W=135n L=40n M=1
Mqpa o a vccxx vccxx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_34
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_34 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx ntgmv W=270n L=120n M=1
Mqpa o a vccxx vccxx ptgmv W=270n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_33
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_33 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlplvt W=180n L=40n M=1
Mqpa o a vccxx vccxx plplvt W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_32
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_32 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx ntgmv W=135n L=120n M=1
Mqpa o a vccxx vccxx ptgmv W=90n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_31
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_31 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx ntgmv W=135n L=120n M=1
Mqpa o a vccxx vccxx ptgmv W=135n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15inv000al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15inv000al1n04x5 a o1 vcc vssx m=1
* .PININFO a:I o1:O vcc:B vssx:B
Mqp1 o1 a vcc vcc plp W=180n L=40n M=1
Mqn1 o1 a vssx vssx nlp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15cinv00xu1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15cinv00xu1n05x5 clkout vccx vssx clk
* .PININFO clk:I clkout:O vccx:B vssx:B
Mqn1 clkout clk vssx vssx ntgmv W=135n L=120n M=1
Mmn0 clkout clk vssx vssx ntgmv W=90n L=120n M=1
Mqp1 clkout clk vccx vccx ptgmv W=135n L=120n M=2
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22imc_ana_p144_mult1_2stack_width
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22imc_ana_p144_mult1_2stack_width d g s vccx
* .PININFO d:B g:B s:B vccx:B
Mmp3 n2 g s vccx pal74 W=180n L=74n M=1
Mmp2 d g n2 vccx pal74 W=180n L=74n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22imc_ana_n144_mult1_4stack_width
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22imc_ana_n144_mult1_4stack_width d g s vssx
* .PININFO d:B g:B s:B vssx:B
Mqn1 d g n4 vssx nal74 W=180n L=74n M=1
Mqn0 n4 g n2 vssx nal74 W=180n L=74n M=1
Mmn1 n2 g n0 vssx nal74 W=180n L=74n M=1
Mmn0 n0 g s vssx nal74 W=180n L=74n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22imc_ana_p216_mult4_tg
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22imc_ana_p216_mult4_tg d g s vccx
* .PININFO d:B g:B s:B vccx:B
Mmp0[4] d g s vccx ptgmv W=180n L=120n M=1
Mmp0[3] d g s vccx ptgmv W=180n L=120n M=1
Mmp0[2] d g s vccx ptgmv W=180n L=120n M=1
Mmp0[1] d g s vccx ptgmv W=180n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    na2_pcell_24
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__na2_pcell_24 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a n1 vssxx nlp W=360n L=40n M=1
Mqnb n1 b vssxx vssxx nlp W=360n L=40n M=1
Mqpb o b vccxx vccxx plp W=270n L=40n M=1
Mqpa o a vccxx vccxx plp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xl1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xl1n04x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqn1 o1 a vssx vssx nlp W=180n L=40n M=1
Mqp1 o1 a vccx vccx plp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_21
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_21 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlp W=90n L=40n M=1
Mqpsb o sb i vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    xf_pcell_20
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xf_pcell_20 i o s sb vccxx vssxx
* .PININFO i:I s:I sb:I o:O vccxx:B vssxx:B
Mqns o s i vssxx nlp W=135n L=40n M=1
Mqpsb o sb i vccxx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    ba2no2_pcell_19
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ba2no2_pcell_19 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=225n L=40n M=1
Mqnb o b n2 vssxx nlp W=360n L=40n M=1
Mqnc n2 c vssxx vssxx nlp W=360n L=40n M=1
Mqpc n1 c vccxx vccxx plp W=360n L=40n M=1
Mqpb n1 b vccxx vccxx plp W=360n L=40n M=1
Mqpa o a n1 vccxx plp W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    ba2no2_pcell_18
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ba2no2_pcell_18 a b c o vccxx vssxx
* .PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=135n L=40n M=1
Mqnb o b n2 vssxx nlp W=135n L=40n M=1
Mqnc n2 c vssxx vssxx nlp W=135n L=40n M=1
Mqpc n1 c vccxx vccxx plp W=135n L=40n M=1
Mqpb n1 b vccxx vccxx plp W=135n L=40n M=1
Mqpa o a n1 vccxx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_17
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_17 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=270n L=40n M=1
Mqpa o a vccxx vccxx plp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_16
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_16 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=90n L=40n M=1
Mqpa o a vccxx vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_15
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_15 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=135n L=40n M=1
Mqpa o a vccxx vccxx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_14
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_14 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=360n L=40n M=1
Mqpa o a vccxx vccxx plp W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    td_pcell_13
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__td_pcell_13 ck ckb d o vccxx vssxx
* .PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqnck o ck n2 vssxx nlp W=90n L=40n M=1
Mqnd n2 d vssxx vssxx nlp W=90n L=40n M=1
Mqpckb o ckb n1 vccxx plp W=90n L=40n M=1
Mqpd n1 d vccxx vccxx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15nand02xl1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15nand02xl1n03x5 o1 vccx vssx a b
* .PININFO a:I b:I o1:O vccx:B vssx:B
Mqn2 n1 b vssx vssx nlp W=135n L=40n M=1
Mqn1 o1 a n1 vssx nlp W=135n L=40n M=1
Mqp2 o1 b vccx vccx plp W=135n L=40n M=1
Mqp1 o1 a vccx vccx plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15nand02xl1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15nand02xl1n12x5 o1 vccx vssx a b
* .PININFO a:I b:I o1:O vccx:B vssx:B
Mqn2 n1 b vssx vssx nlp W=180n L=40n M=3
Mqn1 o1 a n1 vssx nlp W=180n L=40n M=3
Mqp2 o1 b vccx vccx plp W=180n L=40n M=3
Mqp1 o1 a vccx vccx plp W=180n L=40n M=3
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xl1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xl1n05x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqn1 o1 a vssx vssx nlp W=225n L=40n M=1
Mqp1 o1 a vccx vccx plp W=225n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15cinv00xh1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15cinv00xh1n05x5 clkout vccx vssx clk
* .PININFO clk:I clkout:O vccx:B vssx:B
Mmn0 clkout clk vssx vssx nlvt W=90n L=40n M=1
Mqn1 clkout clk vssx vssx nlvt W=135n L=40n M=1
Mqp1 clkout clk vccx vccx plvt W=135n L=40n M=2
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22imc_ana_144_mult1_4dg_5stack
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22imc_ana_144_mult1_4dg_5stack d g s vssx
* .PININFO d:B g:B s:B vssx:B
Mqn0 d g n1 vssx nal74 W=180n L=74n M=1
Mqn1 n1 g n2 vssx nal74 W=180n L=74n M=1
Mqn2 n2 g n0 vssx nal74 W=180n L=74n M=1
Mqn3 n0 g n3 vssx nal74 W=180n L=74n M=1
Mqn4 n3 g s vssx nal74 W=180n L=74n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22imc_ana_p144_mult1_4dg_5stack
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22imc_ana_p144_mult1_4dg_5stack d g s vccx
* .PININFO d:B g:B s:B vccx:B
Mqp0 n1 g d vccx pal74 W=180n L=74n M=1
Mqp1 n2 g n1 vccx pal74 W=180n L=74n M=1
Mqp2 n3 g n2 vccx pal74 W=180n L=74n M=1
Mqp3 n0 g n3 vccx pal74 W=180n L=74n M=1
Mqp4 s g n0 vccx pal74 W=180n L=74n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15nand02xu1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15nand02xu1n12x5 o1 vccx vssx a b
* .PININFO a:I b:I o1:O vccx:B vssx:B
Mqp2 o1 b vccx vccx ptgmv W=180n L=120n M=3
Mqp1 o1 a vccx vccx ptgmv W=180n L=120n M=3
Mqn2 n1 b vssx vssx ntgmv W=180n L=120n M=3
Mqn1 o1 a n1 vssx ntgmv W=180n L=120n M=3
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    no2_pcell_7
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__no2_pcell_7 a b o vccxx vssxx
* .PININFO a:I b:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=270n L=40n M=1
Mqnb o b vssxx vssxx nlp W=270n L=40n M=1
Mqpb n1 b vccxx vccxx plp W=360n L=40n M=1
Mqpa o a n1 vccxx plp W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22legacy
*  Cell Name:    inv_pcell_6
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__inv_pcell_6 a o vccxx vssxx
* .PININFO a:I o:O vccxx:B vssxx:B
Mqna o a vssxx vssxx nlp W=270n L=40n M=2
Mqpa o a vccxx vccxx plp W=270n L=40n M=2
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xu1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xu1n02x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqn1 o1 a vssx vssx ntgmv W=90n L=120n M=1
Mqp1 o1 a vccx vccx ptgmv W=90n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22imc_n_n144_mult2_2stack
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22imc_n_n144_mult2_2stack d g s vssx
* .PININFO d:B g:B s:B vssx:B
Mmn3 n1 g s vssx n W=180n L=40n M=1
Mmn2 d g n1 vssx n W=180n L=40n M=1
Mmn1 d g n0 vssx n W=180n L=40n M=1
Mmn0 n0 g s vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22imc_p_p144_mult2_2stack
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22imc_p_p144_mult2_2stack d g s vccx
* .PININFO d:B g:B s:B vccx:B
Mmp3 n2 g s vccx p W=180n L=40n M=1
Mmp2 d g n2 vccx p W=180n L=40n M=1
Mqp0 d g n1 vccx p W=180n L=40n M=1
Mqp1 n1 g s vccx p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22imc_powergate
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22imc_powergate ldo_en_b vcchv vcchv_gated
* .PININFO ldo_en_b:I vcchv:I vcchv_gated:O
Mmp1[320] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[319] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[318] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[317] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[316] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[315] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[314] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[313] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[312] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[311] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[310] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[309] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[308] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[307] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[306] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[305] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[304] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[303] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[302] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[301] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[300] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[299] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[298] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[297] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[296] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[295] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[294] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[293] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[292] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[291] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[290] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[289] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[288] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[287] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[286] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[285] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[284] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[283] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[282] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[281] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[280] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[279] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[278] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[277] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[276] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[275] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[274] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[273] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[272] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[271] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[270] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[269] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[268] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[267] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[266] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[265] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[264] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[263] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[262] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[261] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[260] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[259] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[258] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[257] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[256] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[255] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[254] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[253] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[252] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[251] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[250] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[249] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[248] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[247] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[246] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[245] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[244] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[243] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[242] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[241] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[240] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[239] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[238] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[237] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[236] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[235] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[234] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[233] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[232] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[231] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[230] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[229] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[228] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[227] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[226] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[225] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[224] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[223] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[222] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[221] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[220] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[219] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[218] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[217] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[216] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[215] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[214] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[213] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[212] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[211] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[210] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[209] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[208] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[207] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[206] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[205] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[204] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[203] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[202] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[201] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[200] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[199] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[198] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[197] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[196] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[195] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[194] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[193] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[192] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[191] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[190] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[189] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[188] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[187] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[186] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[185] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[184] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[183] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[182] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[181] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[180] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[179] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[178] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[177] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[176] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[175] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[174] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[173] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[172] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[171] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[170] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[169] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[168] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[167] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[166] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[165] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[164] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[163] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[162] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[161] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[160] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[159] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[158] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[157] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[156] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[155] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[154] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[153] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[152] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[151] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[150] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[149] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[148] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[147] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[146] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[145] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[144] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[143] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[142] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[141] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[140] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[139] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[138] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[137] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[136] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[135] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[134] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[133] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[132] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[131] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[130] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[129] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[128] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[127] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[126] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[125] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[124] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[123] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[122] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[121] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[120] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[119] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[118] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[117] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[116] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[115] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[114] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[113] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[112] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[111] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[110] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[109] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[108] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[107] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[106] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[105] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[104] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[103] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[102] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[101] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[100] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[99] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[98] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[97] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[96] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[95] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[94] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[93] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[92] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[91] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[90] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[89] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[88] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[87] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[86] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[85] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[84] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[83] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[82] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[81] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[80] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[79] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[78] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[77] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[76] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[75] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[74] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[73] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[72] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[71] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[70] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[69] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[68] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[67] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[66] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[65] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[64] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[63] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[62] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[61] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[60] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[59] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[58] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[57] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[56] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[55] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[54] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[53] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[52] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[51] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[50] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[49] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[48] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[47] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[46] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[45] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[44] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[43] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[42] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[41] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[40] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[39] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[38] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[37] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[36] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[35] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[34] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[33] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[32] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[31] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[30] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[29] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[28] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[27] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[26] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[25] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[24] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[23] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[22] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[21] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[20] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[19] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[18] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[17] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[16] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[15] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[14] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[13] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[12] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[11] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[10] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[9] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[8] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[7] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[6] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[5] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[4] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[3] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[2] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp1[1] vcchv vcchv vcchv vcchv ptgmv W=180n L=120n M=1
Mmp2[320] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[319] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[318] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[317] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[316] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[315] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[314] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[313] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[312] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[311] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[310] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[309] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[308] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[307] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[306] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[305] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[304] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[303] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[302] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[301] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[300] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[299] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[298] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[297] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[296] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[295] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[294] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[293] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[292] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[291] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[290] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[289] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[288] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[287] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[286] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[285] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[284] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[283] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[282] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[281] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[280] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[279] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[278] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[277] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[276] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[275] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[274] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[273] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[272] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[271] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[270] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[269] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[268] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[267] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[266] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[265] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[264] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[263] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[262] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[261] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[260] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[259] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[258] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[257] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[256] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[255] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[254] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[253] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[252] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[251] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[250] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[249] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[248] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[247] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[246] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[245] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[244] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[243] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[242] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[241] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[240] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[239] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[238] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[237] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[236] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[235] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[234] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[233] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[232] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[231] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[230] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[229] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[228] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[227] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[226] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[225] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[224] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[223] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[222] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[221] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[220] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[219] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[218] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[217] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[216] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[215] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[214] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[213] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[212] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[211] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[210] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[209] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[208] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[207] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[206] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[205] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[204] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[203] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[202] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[201] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[200] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[199] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[198] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[197] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[196] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[195] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[194] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[193] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[192] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[191] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[190] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[189] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[188] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[187] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[186] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[185] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[184] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[183] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[182] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[181] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[180] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[179] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[178] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[177] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[176] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[175] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[174] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[173] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[172] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[171] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[170] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[169] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[168] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[167] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[166] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[165] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[164] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[163] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[162] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[161] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[160] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[159] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[158] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[157] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[156] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[155] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[154] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[153] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[152] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[151] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[150] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[149] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[148] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[147] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[146] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[145] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[144] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[143] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[142] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[141] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[140] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[139] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[138] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[137] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[136] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[135] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[134] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[133] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[132] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[131] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[130] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[129] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[128] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[127] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[126] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[125] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[124] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[123] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[122] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[121] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[120] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[119] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[118] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[117] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[116] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[115] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[114] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[113] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[112] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[111] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[110] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[109] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[108] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[107] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[106] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[105] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[104] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[103] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[102] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[101] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[100] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[99] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[98] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[97] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[96] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[95] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[94] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[93] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[92] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[91] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[90] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[89] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[88] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[87] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[86] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[85] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[84] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[83] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[82] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[81] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[80] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[79] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[78] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[77] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[76] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[75] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[74] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[73] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[72] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[71] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[70] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[69] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[68] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[67] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[66] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[65] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[64] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[63] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[62] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[61] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[60] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[59] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[58] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[57] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[56] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[55] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[54] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[53] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[52] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[51] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[50] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[49] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[48] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[47] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[46] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[45] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[44] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[43] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[42] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[41] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[40] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[39] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[38] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[37] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[36] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[35] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[34] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[33] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[32] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[31] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[30] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[29] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[28] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[27] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[26] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[25] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[24] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[23] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[22] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[21] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[20] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[19] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[18] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[17] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[16] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[15] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[14] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[13] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[12] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[11] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[10] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[9] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[8] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[7] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[6] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[5] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[4] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[3] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[2] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mmp2[1] vcchv_gated vcchv_gated vcchv_gated vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1600] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1599] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1598] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1597] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1596] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1595] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1594] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1593] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1592] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1591] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1590] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1589] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1588] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1587] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1586] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1585] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1584] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1583] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1582] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1581] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1580] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1579] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1578] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1577] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1576] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1575] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1574] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1573] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1572] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1571] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1570] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1569] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1568] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1567] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1566] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1565] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1564] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1563] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1562] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1561] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1560] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1559] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1558] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1557] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1556] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1555] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1554] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1553] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1552] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1551] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1550] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1549] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1548] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1547] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1546] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1545] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1544] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1543] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1542] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1541] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1540] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1539] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1538] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1537] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1536] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1535] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1534] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1533] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1532] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1531] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1530] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1529] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1528] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1527] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1526] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1525] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1524] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1523] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1522] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1521] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1520] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1519] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1518] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1517] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1516] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1515] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1514] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1513] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1512] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1511] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1510] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1509] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1508] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1507] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1506] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1505] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1504] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1503] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1502] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1501] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1500] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1499] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1498] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1497] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1496] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1495] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1494] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1493] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1492] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1491] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1490] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1489] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1488] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1487] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1486] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1485] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1484] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1483] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1482] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1481] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1480] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1479] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1478] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1477] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1476] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1475] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1474] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1473] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1472] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1471] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1470] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1469] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1468] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1467] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1466] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1465] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1464] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1463] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1462] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1461] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1460] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1459] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1458] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1457] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1456] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1455] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1454] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1453] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1452] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1451] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1450] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1449] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1448] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1447] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1446] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1445] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1444] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1443] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1442] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1441] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1440] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1439] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1438] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1437] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1436] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1435] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1434] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1433] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1432] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1431] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1430] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1429] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1428] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1427] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1426] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1425] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1424] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1423] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1422] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1421] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1420] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1419] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1418] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1417] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1416] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1415] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1414] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1413] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1412] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1411] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1410] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1409] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1408] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1407] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1406] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1405] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1404] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1403] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1402] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1401] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1400] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1399] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1398] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1397] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1396] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1395] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1394] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1393] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1392] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1391] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1390] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1389] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1388] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1387] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1386] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1385] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1384] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1383] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1382] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1381] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1380] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1379] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1378] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1377] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1376] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1375] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1374] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1373] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1372] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1371] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1370] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1369] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1368] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1367] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1366] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1365] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1364] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1363] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1362] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1361] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1360] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1359] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1358] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1357] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1356] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1355] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1354] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1353] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1352] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1351] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1350] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1349] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1348] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1347] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1346] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1345] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1344] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1343] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1342] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1341] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1340] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1339] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1338] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1337] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1336] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1335] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1334] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1333] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1332] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1331] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1330] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1329] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1328] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1327] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1326] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1325] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1324] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1323] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1322] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1321] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1320] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1319] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1318] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1317] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1316] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1315] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1314] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1313] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1312] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1311] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1310] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1309] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1308] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1307] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1306] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1305] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1304] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1303] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1302] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1301] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1300] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1299] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1298] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1297] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1296] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1295] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1294] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1293] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1292] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1291] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1290] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1289] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1288] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1287] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1286] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1285] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1284] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1283] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1282] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1281] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1280] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1279] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1278] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1277] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1276] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1275] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1274] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1273] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1272] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1271] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1270] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1269] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1268] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1267] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1266] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1265] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1264] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1263] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1262] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1261] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1260] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1259] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1258] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1257] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1256] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1255] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1254] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1253] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1252] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1251] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1250] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1249] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1248] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1247] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1246] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1245] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1244] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1243] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1242] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1241] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1240] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1239] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1238] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1237] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1236] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1235] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1234] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1233] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1232] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1231] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1230] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1229] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1228] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1227] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1226] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1225] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1224] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1223] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1222] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1221] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1220] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1219] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1218] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1217] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1216] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1215] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1214] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1213] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1212] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1211] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1210] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1209] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1208] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1207] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1206] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1205] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1204] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1203] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1202] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1201] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1200] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1199] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1198] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1197] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1196] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1195] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1194] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1193] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1192] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1191] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1190] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1189] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1188] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1187] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1186] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1185] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1184] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1183] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1182] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1181] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1180] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1179] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1178] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1177] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1176] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1175] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1174] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1173] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1172] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1171] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1170] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1169] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1168] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1167] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1166] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1165] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1164] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1163] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1162] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1161] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1160] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1159] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1158] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1157] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1156] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1155] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1154] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1153] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1152] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1151] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1150] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1149] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1148] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1147] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1146] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1145] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1144] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1143] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1142] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1141] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1140] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1139] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1138] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1137] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1136] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1135] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1134] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1133] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1132] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1131] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1130] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1129] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1128] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1127] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1126] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1125] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1124] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1123] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1122] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1121] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1120] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1119] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1118] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1117] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1116] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1115] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1114] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1113] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1112] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1111] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1110] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1109] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1108] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1107] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1106] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1105] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1104] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1103] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1102] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1101] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1100] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1099] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1098] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1097] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1096] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1095] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1094] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1093] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1092] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1091] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1090] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1089] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1088] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1087] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1086] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1085] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1084] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1083] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1082] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1081] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1080] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1079] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1078] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1077] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1076] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1075] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1074] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1073] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1072] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1071] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1070] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1069] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1068] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1067] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1066] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1065] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1064] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1063] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1062] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1061] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1060] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1059] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1058] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1057] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1056] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1055] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1054] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1053] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1052] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1051] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1050] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1049] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1048] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1047] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1046] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1045] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1044] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1043] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1042] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1041] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1040] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1039] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1038] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1037] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1036] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1035] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1034] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1033] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1032] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1031] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1030] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1029] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1028] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1027] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1026] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1025] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1024] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1023] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1022] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1021] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1020] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1019] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1018] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1017] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1016] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1015] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1014] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1013] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1012] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1011] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1010] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1009] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1008] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1007] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1006] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1005] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1004] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1003] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1002] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1001] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1000] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[999] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[998] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[997] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[996] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[995] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[994] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[993] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[992] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[991] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[990] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[989] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[988] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[987] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[986] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[985] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[984] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[983] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[982] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[981] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[980] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[979] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[978] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[977] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[976] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[975] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[974] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[973] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[972] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[971] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[970] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[969] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[968] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[967] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[966] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[965] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[964] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[963] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[962] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[961] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[960] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[959] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[958] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[957] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[956] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[955] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[954] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[953] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[952] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[951] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[950] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[949] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[948] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[947] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[946] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[945] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[944] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[943] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[942] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[941] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[940] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[939] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[938] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[937] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[936] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[935] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[934] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[933] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[932] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[931] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[930] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[929] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[928] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[927] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[926] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[925] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[924] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[923] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[922] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[921] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[920] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[919] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[918] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[917] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[916] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[915] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[914] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[913] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[912] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[911] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[910] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[909] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[908] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[907] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[906] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[905] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[904] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[903] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[902] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[901] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[900] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[899] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[898] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[897] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[896] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[895] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[894] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[893] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[892] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[891] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[890] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[889] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[888] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[887] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[886] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[885] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[884] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[883] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[882] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[881] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[880] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[879] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[878] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[877] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[876] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[875] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[874] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[873] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[872] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[871] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[870] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[869] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[868] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[867] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[866] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[865] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[864] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[863] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[862] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[861] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[860] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[859] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[858] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[857] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[856] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[855] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[854] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[853] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[852] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[851] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[850] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[849] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[848] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[847] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[846] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[845] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[844] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[843] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[842] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[841] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[840] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[839] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[838] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[837] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[836] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[835] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[834] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[833] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[832] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[831] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[830] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[829] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[828] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[827] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[826] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[825] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[824] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[823] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[822] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[821] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[820] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[819] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[818] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[817] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[816] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[815] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[814] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[813] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[812] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[811] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[810] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[809] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[808] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[807] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[806] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[805] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[804] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[803] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[802] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[801] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[800] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[799] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[798] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[797] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[796] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[795] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[794] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[793] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[792] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[791] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[790] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[789] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[788] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[787] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[786] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[785] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[784] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[783] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[782] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[781] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[780] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[779] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[778] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[777] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[776] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[775] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[774] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[773] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[772] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[771] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[770] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[769] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[768] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[767] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[766] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[765] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[764] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[763] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[762] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[761] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[760] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[759] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[758] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[757] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[756] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[755] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[754] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[753] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[752] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[751] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[750] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[749] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[748] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[747] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[746] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[745] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[744] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[743] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[742] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[741] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[740] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[739] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[738] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[737] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[736] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[735] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[734] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[733] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[732] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[731] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[730] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[729] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[728] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[727] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[726] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[725] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[724] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[723] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[722] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[721] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[720] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[719] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[718] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[717] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[716] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[715] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[714] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[713] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[712] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[711] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[710] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[709] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[708] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[707] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[706] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[705] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[704] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[703] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[702] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[701] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[700] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[699] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[698] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[697] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[696] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[695] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[694] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[693] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[692] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[691] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[690] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[689] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[688] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[687] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[686] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[685] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[684] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[683] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[682] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[681] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[680] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[679] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[678] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[677] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[676] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[675] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[674] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[673] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[672] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[671] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[670] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[669] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[668] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[667] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[666] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[665] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[664] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[663] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[662] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[661] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[660] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[659] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[658] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[657] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[656] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[655] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[654] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[653] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[652] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[651] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[650] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[649] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[648] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[647] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[646] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[645] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[644] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[643] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[642] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[641] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[640] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[639] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[638] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[637] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[636] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[635] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[634] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[633] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[632] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[631] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[630] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[629] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[628] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[627] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[626] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[625] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[624] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[623] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[622] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[621] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[620] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[619] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[618] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[617] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[616] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[615] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[614] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[613] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[612] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[611] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[610] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[609] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[608] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[607] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[606] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[605] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[604] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[603] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[602] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[601] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[600] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[599] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[598] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[597] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[596] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[595] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[594] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[593] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[592] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[591] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[590] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[589] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[588] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[587] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[586] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[585] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[584] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[583] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[582] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[581] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[580] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[579] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[578] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[577] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[576] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[575] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[574] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[573] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[572] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[571] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[570] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[569] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[568] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[567] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[566] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[565] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[564] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[563] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[562] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[561] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[560] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[559] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[558] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[557] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[556] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[555] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[554] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[553] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[552] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[551] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[550] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[549] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[548] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[547] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[546] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[545] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[544] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[543] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[542] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[541] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[540] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[539] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[538] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[537] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[536] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[535] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[534] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[533] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[532] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[531] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[530] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[529] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[528] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[527] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[526] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[525] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[524] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[523] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[522] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[521] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[520] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[519] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[518] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[517] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[516] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[515] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[514] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[513] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[512] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[511] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[510] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[509] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[508] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[507] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[506] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[505] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[504] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[503] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[502] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[501] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[500] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[499] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[498] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[497] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[496] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[495] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[494] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[493] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[492] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[491] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[490] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[489] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[488] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[487] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[486] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[485] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[484] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[483] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[482] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[481] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[480] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[479] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[478] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[477] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[476] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[475] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[474] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[473] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[472] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[471] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[470] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[469] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[468] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[467] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[466] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[465] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[464] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[463] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[462] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[461] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[460] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[459] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[458] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[457] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[456] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[455] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[454] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[453] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[452] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[451] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[450] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[449] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[448] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[447] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[446] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[445] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[444] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[443] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[442] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[441] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[440] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[439] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[438] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[437] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[436] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[435] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[434] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[433] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[432] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[431] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[430] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[429] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[428] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[427] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[426] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[425] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[424] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[423] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[422] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[421] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[420] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[419] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[418] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[417] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[416] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[415] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[414] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[413] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[412] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[411] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[410] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[409] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[408] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[407] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[406] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[405] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[404] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[403] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[402] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[401] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[400] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[399] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[398] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[397] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[396] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[395] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[394] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[393] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[392] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[391] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[390] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[389] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[388] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[387] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[386] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[385] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[384] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[383] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[382] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[381] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[380] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[379] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[378] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[377] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[376] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[375] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[374] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[373] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[372] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[371] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[370] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[369] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[368] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[367] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[366] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[365] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[364] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[363] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[362] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[361] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[360] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[359] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[358] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[357] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[356] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[355] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[354] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[353] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[352] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[351] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[350] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[349] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[348] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[347] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[346] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[345] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[344] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[343] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[342] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[341] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[340] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[339] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[338] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[337] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[336] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[335] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[334] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[333] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[332] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[331] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[330] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[329] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[328] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[327] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[326] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[325] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[324] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[323] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[322] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[321] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[320] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[319] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[318] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[317] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[316] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[315] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[314] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[313] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[312] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[311] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[310] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[309] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[308] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[307] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[306] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[305] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[304] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[303] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[302] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[301] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[300] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[299] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[298] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[297] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[296] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[295] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[294] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[293] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[292] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[291] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[290] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[289] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[288] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[287] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[286] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[285] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[284] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[283] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[282] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[281] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[280] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[279] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[278] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[277] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[276] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[275] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[274] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[273] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[272] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[271] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[270] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[269] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[268] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[267] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[266] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[265] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[264] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[263] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[262] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[261] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[260] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[259] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[258] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[257] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[256] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[255] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[254] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[253] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[252] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[251] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[250] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[249] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[248] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[247] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[246] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[245] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[244] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[243] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[242] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[241] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[240] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[239] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[238] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[237] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[236] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[235] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[234] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[233] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[232] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[231] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[230] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[229] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[228] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[227] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[226] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[225] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[224] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[223] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[222] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[221] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[220] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[219] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[218] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[217] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[216] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[215] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[214] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[213] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[212] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[211] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[210] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[209] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[208] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[207] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[206] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[205] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[204] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[203] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[202] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[201] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[200] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[199] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[198] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[197] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[196] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[195] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[194] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[193] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[192] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[191] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[190] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[189] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[188] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[187] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[186] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[185] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[184] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[183] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[182] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[181] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[180] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[179] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[178] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[177] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[176] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[175] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[174] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[173] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[172] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[171] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[170] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[169] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[168] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[167] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[166] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[165] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[164] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[163] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[162] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[161] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[160] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[159] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[158] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[157] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[156] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[155] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[154] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[153] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[152] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[151] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[150] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[149] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[148] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[147] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[146] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[145] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[144] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[143] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[142] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[141] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[140] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[139] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[138] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[137] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[136] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[135] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[134] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[133] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[132] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[131] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[130] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[129] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[128] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[127] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[126] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[125] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[124] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[123] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[122] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[121] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[120] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[119] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[118] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[117] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[116] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[115] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[114] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[113] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[112] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[111] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[110] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[109] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[108] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[107] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[106] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[105] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[104] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[103] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[102] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[101] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[100] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[99] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[98] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[97] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[96] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[95] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[94] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[93] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[92] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[91] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[90] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[89] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[88] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[87] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[86] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[85] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[84] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[83] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[82] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[81] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[80] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[79] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[78] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[77] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[76] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[75] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[74] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[73] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[72] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[71] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[70] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[69] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[68] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[67] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[66] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[65] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[64] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[63] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[62] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[61] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[60] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[59] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[58] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[57] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[56] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[55] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[54] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[53] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[52] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[51] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[50] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[49] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[48] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[47] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[46] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[45] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[44] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[43] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[42] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[41] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[40] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[39] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[38] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[37] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[36] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[35] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[34] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[33] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[32] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[31] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[30] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[29] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[28] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[27] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[26] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[25] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[24] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[23] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[22] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[21] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[20] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[19] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[18] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[17] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[16] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[15] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[14] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[13] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[12] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[11] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[10] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[9] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[8] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[7] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[6] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[5] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[4] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[3] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[2] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
Mpwrgt[1] vcchv_gated ldo_en_b vcchv vcchv ptgmv W=180n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xn1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xn1n03x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqp1 o1 a vccx vccx p W=135n L=40n M=1
Mqn1 o1 a vssx vssx n W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_tgate
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_tgate io1 io2 en en_b vccxx vssx
* .PININFO en:I en_b:I vccxx:I vssx:I io1:B io2:B
Mqp2[4] io2 en_b n1 n1 p W=180n L=40n M=1
Mqp2[3] io2 en_b n1 n1 p W=180n L=40n M=1
Mqp2[2] io2 en_b n1 n1 p W=180n L=40n M=1
Mqp2[1] io2 en_b n1 n1 p W=180n L=40n M=1
Mqp1[4] n1 en_b io1 n1 p W=180n L=40n M=1
Mqp1[3] n1 en_b io1 n1 p W=180n L=40n M=1
Mqp1[2] n1 en_b io1 n1 p W=180n L=40n M=1
Mqp1[1] n1 en_b io1 n1 p W=180n L=40n M=1
Mqn1[4] n0 en io1 vssx n W=180n L=40n M=1
Mqn1[3] n0 en io1 vssx n W=180n L=40n M=1
Mqn1[2] n0 en io1 vssx n W=180n L=40n M=1
Mqn1[1] n0 en io1 vssx n W=180n L=40n M=1
Mqn2[4] io2 en n0 vssx n W=180n L=40n M=1
Mqn2[3] io2 en n0 vssx n W=180n L=40n M=1
Mqn2[2] io2 en n0 vssx n W=180n L=40n M=1
Mqn2[1] io2 en n0 vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_tgate_ll
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_tgate_ll io1 io2 en en_b vccxx vssx
* .PININFO en:I en_b:I vccxx:I vssx:I io1:B io2:B
Mqn1[4] n0 en io1 vssx ntgmv W=180n L=120n M=1
Mqn1[3] n0 en io1 vssx ntgmv W=180n L=120n M=1
Mqn1[2] n0 en io1 vssx ntgmv W=180n L=120n M=1
Mqn1[1] n0 en io1 vssx ntgmv W=180n L=120n M=1
Mqn2[4] io2 en n0 vssx ntgmv W=180n L=120n M=1
Mqn2[3] io2 en n0 vssx ntgmv W=180n L=120n M=1
Mqn2[2] io2 en n0 vssx ntgmv W=180n L=120n M=1
Mqn2[1] io2 en n0 vssx ntgmv W=180n L=120n M=1
Mqp2[4] io2 en_b n1 n1 ptgmv W=180n L=120n M=1
Mqp2[3] io2 en_b n1 n1 ptgmv W=180n L=120n M=1
Mqp2[2] io2 en_b n1 n1 ptgmv W=180n L=120n M=1
Mqp2[1] io2 en_b n1 n1 ptgmv W=180n L=120n M=1
Mqp1[4] n1 en_b io1 n1 ptgmv W=180n L=120n M=1
Mqp1[3] n1 en_b io1 n1 ptgmv W=180n L=120n M=1
Mqp1[2] n1 en_b io1 n1 ptgmv W=180n L=120n M=1
Mqp1[1] n1 en_b io1 n1 ptgmv W=180n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xu1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xu1n06x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqp1 o1 a vccx vccx ptgmv W=135n L=120n M=2
Mqn1 o1 a vssx vssx ntgmv W=135n L=120n M=2
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xu1n20x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xu1n20x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqp1 o1 a vccx vccx ptgmv W=180n L=120n M=5
Mqn1 o1 a vssx vssx ntgmv W=180n L=120n M=5
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xu1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xu1n05x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqp1 o1 a vccx vccx ptgmv W=225n L=120n M=1
Mqn1 o1 a vssx vssx ntgmv W=225n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_tgate_ref
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_tgate_ref io1 io2 en en_b vccxx vddh vssx
* .PININFO en:I en_b:I vccxx:I vddh:I vssx:I io1:B io2:B
Mqp2[4] io2 en_b n1 vddh p W=180n L=40n M=1
Mqp2[3] io2 en_b n1 vddh p W=180n L=40n M=1
Mqp2[2] io2 en_b n1 vddh p W=180n L=40n M=1
Mqp2[1] io2 en_b n1 vddh p W=180n L=40n M=1
Mqp1[4] n1 en_b io1 vddh p W=180n L=40n M=1
Mqp1[3] n1 en_b io1 vddh p W=180n L=40n M=1
Mqp1[2] n1 en_b io1 vddh p W=180n L=40n M=1
Mqp1[1] n1 en_b io1 vddh p W=180n L=40n M=1
Mqn1[4] n0 en io1 vssx n W=180n L=40n M=1
Mqn1[3] n0 en io1 vssx n W=180n L=40n M=1
Mqn1[2] n0 en io1 vssx n W=180n L=40n M=1
Mqn1[1] n0 en io1 vssx n W=180n L=40n M=1
Mqn2[4] io2 en n0 vssx n W=180n L=40n M=1
Mqn2[3] io2 en n0 vssx n W=180n L=40n M=1
Mqn2[2] io2 en n0 vssx n W=180n L=40n M=1
Mqn2[1] io2 en n0 vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xn1n05x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xn1n05x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqn1 o1 a vssx vssx n W=225n L=40n M=1
Mqp1 o1 a vccx vccx p W=225n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xn1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xn1n06x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqp1 o1 a vccx vccx p W=135n L=40n M=2
Mqn1 o1 a vssx vssx n W=135n L=40n M=2
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15nand24xn1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15nand24xn1n08x5 o1 vccx vssx a b c d
* .PININFO a:I b:I c:I d:I o1:O vccx:B vssx:B
Mqp2 o1 b vccx vccx p W=270n L=40n M=1
Mqp3 o1 c vccx vccx p W=270n L=40n M=1
Mqp4 o1 d vccx vccx p W=270n L=40n M=1
Mqp1 o1 a vccx vccx p W=270n L=40n M=1
Mqn1 o1 a n1 vssx n W=360n L=40n M=1
Mqn2 n1 b n2 vssx n W=360n L=40n M=1
Mqn3 n2 c n3 vssx n W=360n L=40n M=1
Mqn4 n3 d vssx vssx n W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xn1n32x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xn1n32x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqn1 o1 a vssx vssx n W=180n L=40n M=8
Mqp1 o1 a vccx vccx p W=180n L=40n M=8
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xn1n20x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xn1n20x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqn1 o1 a vssx vssx n W=225n L=40n M=4
Mqp1 o1 a vccx vccx p W=225n L=40n M=4
.ENDS

* .RESVAL
* .CAPVAL
* .DIOPERI
* .DIOAREA
* .EQUATION
* .EXPAND_ON_M_FACTOR
* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15inv000xn1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15inv000xn1n12x5 o1 vccx vssx a
* .PININFO a:I o1:O vccx:B vssx:B
Mqp1 o1 a vccx vccx p W=180n L=40n M=3
Mqn1 o1 a vssx vssx n W=180n L=40n M=3
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd1ru6ogd8kvunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddjpu1ogdxnxunx
* ***********************************************************************
.SUBCKT b88xesddjpu1ogdxnxunx pad_uhv vcc_uhv
* .PININFO pad_uhv:B vcc_uhv:B
Ddjpmid[7] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpmid[6] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpmid[5] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpmid[4] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpmid[3] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpmid[2] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpmid[1] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpmid[0] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjptop[7] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjptop[6] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjptop[5] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjptop[4] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjptop[3] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjptop[2] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjptop[1] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjptop[0] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpbot[7] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpbot[6] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpbot[5] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpbot[4] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpbot[3] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpbot[2] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpbot[1] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjpbot[0] pad_uhv vcc_uhv b88djpesd_prim AREA=0.02448p PJ=0.856u M=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: inductor_2t
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: inductor_3t
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2tmpqlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2tmrqlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2tmcqlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2tm0qlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2pt0qlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn4000qlxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn6000qlxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdclpn6000qlxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddjnutnwlqnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddjnu6nwlqnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd1ru6nwlqnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdd1ru6nwlqnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xbgdpnpxx000xxxhsx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xbgd000h1000xm8unx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmbgdh6410xmxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddjnu1ogdxnxunx
* ***********************************************************************
.SUBCKT b88xesddjnu1ogdxnxunx pad_uhv vssx
* .PININFO pad_uhv:B vssx:B
Ddjnbot[7] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnbot[6] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnbot[5] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnbot[4] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnbot[3] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnbot[2] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnbot[1] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnbot[0] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnmid[7] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnmid[6] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnmid[5] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnmid[4] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnmid[3] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnmid[2] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnmid[1] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjnmid[0] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjntop[7] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjntop[6] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjntop[5] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjntop[4] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjntop[3] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjntop[2] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjntop[1] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
Ddjntop[0] vssx pad_uhv b88djnesd_prim AREA=0.02448p PJ=0.856u M=1
.ENDS

.SUBCKT b88xp_tfr_dnw a b vssx
* .PININFO a:B b:B vssx:B
.ENDS

.SUBCKT b88xp_tfr a b nwl
* .PININFO a:B b:B nwl:B
.ENDS

.SUBCKT b88xp_mfcs2g a b
* .PININFO a:B b:B
.ENDS

.SUBCKT b88xp_mfcs2p a b vssx
* .PININFO a:B b:B vssx:B
.ENDS

.SUBCKT b88xp_mfcs2sls a b lowershield vssx
* .PININFO a:B b:B lowershield:B vssx:B
.ENDS

.SUBCKT b88xp_mfcs2s a b lowershield uppershield vssx
* .PININFO a:B b:B lowershield:B uppershield:B vssx:B
.ENDS

* ** Start of intel22custom.cdl
.SUBCKT b88xp_dcps2p a b
* .PININFO a:B b:B
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_inbuf_hn_clk
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_inbuf_hn_clk o1 o2 a vccx vssx
* .PININFO a:I vccx:I vssx:I o1:O o2:O
Xcinv1 clkb o2 vccx vssx ringpll__b15cinv00ah1n12x5 m=1
Xcinv0 a clkb vccx vssx ringpll__b15cinv00ah1n12x5 m=1
Xcinv2 clkb o1 vccx vssx ringpll__b15cinv00ah1n12x5 m=1
Xydpd0 a vccx vssx ringpll__b15ydp151an1n03x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cbf000ah1n24x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000ah1n24x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plvt W=270n L=40n M=1
Mqn1 n0 clk vssx vssx nlvt W=270n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_178
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15cilb81al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cilb81al1n02x5 clk clkout en te vcc vssx m=1
* .PININFO clk:I en:I te:I clkout:O vcc:B vssx:B
Xg42 te en n8 vcc vssx ringpll__no2_pcell_55
Xg43 clk n7 nc9 vcc vssx ringpll__no2_pcell_177
Xg1 nc3 nc2 vcc vssx ringpll__inv_pcell_44
Xg0 clk nc3 vcc vssx ringpll__inv_pcell_44
Xg5 nk2 n7 vcc vssx ringpll__inv_pcell_38
Xg201 nc9 clkout vcc vssx ringpll__inv_pcell_44
Xg4 nk1 nk2 vcc vssx ringpll__inv_pcell_38
Xg3 nc3 nc2 nk2 nk1 vcc vssx ringpll__td_pcell_45
Xg2 n8 nk1 nc2 nc3 vcc vssx ringpll__xf_pcell_37
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nonb03ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nonb03ah1n03x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg0 a n1 vcc vssx ringpll__inv_pcell_51
Xg1 n1 b c out0 vcc vssx ringpll__no3_pcell_176
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nonb03al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nonb03al1n02x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg0 a n1 vcc vssx ringpll__inv_pcell_38
Xg1 n1 b c out0 vcc vssx ringpll__no3_pcell_175
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15naoai3en1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15naoai3en1n12x5 a b c d out0 vcc vssx m=1
* .PININFO a:I b:I c:I d:I out0:O vcc:B vssx:B
Mqn1 out0 n1 n2 vssx n W=540n L=40n M=1
Mqn2 n2 c vssx vssx n W=540n L=40n M=1
Mqn3 n2 d vssx vssx n W=540n L=40n M=1
Mqp3 n3 d vcc vcc p W=540n L=40n M=1
Mqp1 out0 n1 vcc vcc p W=360n L=40n M=1
Mqp2 out0 c n3 vcc p W=540n L=40n M=1
Xg1 a b n1 vcc vssx ringpll__na2_pcell_174
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15and002ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002ah1n04x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_173
Xg101 n1 o vcc vssx ringpll__inv_pcell_69
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cbf000ah1n48x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000ah1n48x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plvt W=540n L=40n M=1
Mqn1 n0 clk vssx vssx nlvt W=540n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_172
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15aob012an1n24x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aob012an1n24x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg0 b c n1 vcc vssx ringpll__na2_pcell_170
Xg1 a n1 out0 vcc vssx ringpll__na2_pcell_171
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15rt0022en1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15rt0022en1n02x5 a b carry sum vcc vssx m=1
* .PININFO a:I b:I carry:O sum:O vcc:B vssx:B
Mqp11 n1 a n0 vcc p W=90n L=40n M=1
Mqp20 n1 n9 vcc vcc p W=90n L=40n M=1
Mqp10 n0 b vcc vcc p W=90n L=40n M=1
Xg101 n1 sum vcc vssx ringpll__inv_pcell_169
Xg102 n9 carry vcc vssx ringpll__inv_pcell_169
Xg12 a b n9 vcc vssx ringpll__na2_pcell_149
Mqn11 n1 a n2 vssx n W=90n L=40n M=1
Mqn20 n1 b n2 vssx n W=90n L=40n M=1
Mqn10 n2 n9 vssx vssx n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15aob012an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aob012an1n04x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg0 b c n1 vcc vssx ringpll__na2_pcell_95
Xg1 a n1 out0 vcc vssx ringpll__na2_pcell_168
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15naoai3en1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15naoai3en1n08x5 a b c d out0 vcc vssx m=1
* .PININFO a:I b:I c:I d:I out0:O vcc:B vssx:B
Mqn1 out0 n1 n2 vssx n W=360n L=40n M=1
Mqn2 n2 c vssx vssx n W=360n L=40n M=1
Mqn3 n2 d vssx vssx n W=360n L=40n M=1
Mqp3 n3 d vcc vcc p W=360n L=40n M=1
Mqp1 out0 n1 vcc vcc p W=270n L=40n M=1
Mqp2 out0 c n3 vcc p W=360n L=40n M=1
Xg1 a b n1 vcc vssx ringpll__na2_pcell_168
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15and002an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002an1n04x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_168
Xg101 n1 o vcc vssx ringpll__inv_pcell_116
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15oab012ah1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oab012ah1n02x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg1 a n1 out0 vcc vssx ringpll__no2_pcell_166
Xg0 b c n1 vcc vssx ringpll__no2_pcell_167
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nonb02ah1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nonb02ah1n02x3 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg0 a n1 vcc vssx ringpll__inv_pcell_51
Xg1 n1 b out0 vcc vssx ringpll__no2_pcell_167
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nonb03an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nonb03an1n03x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg0 a n1 vcc vssx ringpll__inv_pcell_97
Xg1 n1 b c out0 vcc vssx ringpll__no3_pcell_165
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nonb03ah1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nonb03ah1n02x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg0 a n1 vcc vssx ringpll__inv_pcell_51
Xg1 n1 b c out0 vcc vssx ringpll__no3_pcell_164
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15and002ah1n24x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002ah1n24x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_163
Xg101 n1 o vcc vssx ringpll__inv_pcell_77
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nanb02ah1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nanb02ah1n16x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg1 n1 b out0 vcc vssx ringpll__na2_pcell_163
Xg0 a n1 vcc vssx ringpll__inv_pcell_52
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15fpn040an1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fpn040an1n08x5 clk d den o vcc vssx m=1
* .PININFO clk:I d:I den:I o:O vcc:B vssx:B
Xg0 n71 n0 vcc vssx ringpll__inv_pcell_116
Xg22 den n81 vcc vssx ringpll__inv_pcell_97
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_68
Xg101 nk5 o vcc vssx ringpll__inv_pcell_158
Xgd1n nk3 nk4 vcc vssx ringpll__inv_pcell_159
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_97
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_51
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_160
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_161
Xg23 n81 den nk6 n71 vcc vssx ringpll__td_pcell_98
Xgd2 nc1 nc2 nk6 nk5 vcc vssx ringpll__td_pcell_98
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_98
Xg21 den n81 d n71 vcc vssx ringpll__td_pcell_162
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15bfn001an1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn001an1n06x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Mqn1 n1 a vssx vssx n W=135n L=40n M=1
Mqp1 n1 a vcc vcc p W=135n L=40n M=1
Xg101 n1 o vcc vssx ringpll__inv_pcell_159
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cbf000ah1n64x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000ah1n64x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plvt W=720n L=40n M=1
Mqn1 n0 clk vssx vssx nlvt W=720n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_157
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15fqy003ah1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqy003ah1n02x5 clk d o rb si ssb vcc vssx m=1
* .PININFO clk:I d:I rb:I si:I ssb:I o:O vcc:B vssx:B
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_156
Mqp4 nk5 rb vcc vcc plvt W=90n L=40n M=1
Mqp5 nk5 nc2 nk11 vcc plvt W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plvt W=90n L=40n M=1
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_66
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_66
Xg101 nk5 o vcc vssx ringpll__inv_pcell_51
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_51
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_51
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_51
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_51
Xg0 n801 n0 vcc vssx ringpll__inv_pcell_51
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_67
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_67
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_67
Mqn4 nk9 rb vssx vssx nlvt W=90n L=40n M=1
Mqn6 nk10 nk6 nk9 vssx nlvt W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nonb03an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nonb03an1n02x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg0 a n1 vcc vssx ringpll__inv_pcell_97
Xg1 n1 b c out0 vcc vssx ringpll__no3_pcell_155
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cmbn22ah1n32x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cmbn22ah1n32x5 clk1 clk2 clkout s vcc vssx m=1
* .PININFO clk1:I clk2:I s:I clkout:O vcc:B vssx:B
Xg4 n2 n3 n4 s vcc vssx ringpll__xf_pcell_152
Xg2 n1 n3 s n4 vcc vssx ringpll__xf_pcell_152
Xg201 n3 clkout vcc vssx ringpll__inv_pcell_153
Xg6 s n4 vcc vssx ringpll__inv_pcell_69
Xg3 clk2 n2 vcc vssx ringpll__inv_pcell_154
Xg1 clk1 n1 vcc vssx ringpll__inv_pcell_154
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqy08fal1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqy08fal1n04x5 clkb d o psb rb si ssb vcc vssx m=1
* .PININFO clkb:I d:I psb:I rb:I si:I ssb:I o:O vcc:B vssx:B
Xgd2n nk5 psb nk6 vcc vssx ringpll__na2_pcell_56
Xgd1n rb nk3 n14 nk4 vcc vssx ringpll__bo2na2_pcell_151
Xgtd2 nk4 nk5 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgtd1 n0 nk3 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xg101 nk5 o vcc vssx ringpll__inv_pcell_36
Xg11 psb n14 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgclkn clkb nc1 vcc vssx ringpll__inv_pcell_44
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_38
Xg0 n801 n0 vcc vssx ringpll__inv_pcell_38
Xgd1 nc1 nc2 nk4 nk3 vcc vssx ringpll__td_pcell_45
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_45
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_45
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Mqp5 nk5 nc1 nk11 vcc plp W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc2 nk10 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15cilb01al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cilb01al1n04x5 clk clkout en te vcc vssx m=1
* .PININFO clk:I en:I te:I clkout:O vcc:B vssx:B
Xg42 te en n8 vcc vssx ringpll__no2_pcell_76
Xg43 clk n7 nc9 vcc vssx ringpll__na2_pcell_150
Xg1 nc3 nc2 vcc vssx ringpll__inv_pcell_44
Xg0 clk nc3 vcc vssx ringpll__inv_pcell_44
Xg4 nk1 nk2 vcc vssx ringpll__inv_pcell_38
Xg201 nc9 clkout vcc vssx ringpll__inv_pcell_63
Xg5 nk1 n7 vcc vssx ringpll__inv_pcell_38
Xg3 nc2 nc3 nk2 nk1 vcc vssx ringpll__td_pcell_45
Xg2 n8 nk1 nc3 nc2 vcc vssx ringpll__xf_pcell_37
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nanb02an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nanb02an1n02x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg1 n1 b out0 vcc vssx ringpll__na2_pcell_149
Xg0 a n1 vcc vssx ringpll__inv_pcell_97
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15naoai3en1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15naoai3en1n04x5 a b c d out0 vcc vssx m=1
* .PININFO a:I b:I c:I d:I out0:O vcc:B vssx:B
Mqn1 out0 n1 n2 vssx n W=180n L=40n M=1
Mqn2 n2 c vssx vssx n W=180n L=40n M=1
Mqn3 n2 d vssx vssx n W=180n L=40n M=1
Mqp3 n3 d vcc vcc p W=180n L=40n M=1
Mqp1 out0 n1 vcc vcc p W=135n L=40n M=1
Mqp2 out0 c n3 vcc p W=180n L=40n M=1
Xg1 a b n1 vcc vssx ringpll__na2_pcell_149
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqn08fal1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn08fal1n02x5 clkb d o psb rb vcc vssx m=1
* .PININFO clkb:I d:I psb:I rb:I o:O vcc:B vssx:B
Xgd2n nk5 psb nk6 vcc vssx ringpll__na2_pcell_56
Xgd1n rb nk3 n14 nk4 vcc vssx ringpll__bo2na2_pcell_148
Xgtd2 nk4 nk5 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgtd1 n0 nk3 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xg101 nk5 o vcc vssx ringpll__inv_pcell_38
Xg11 psb n14 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgclkn clkb nc1 vcc vssx ringpll__inv_pcell_44
Xg1 d n9 vcc vssx ringpll__inv_pcell_38
Xg0 n9 n0 vcc vssx ringpll__inv_pcell_38
Xgd1 nc1 nc2 nk4 nk3 vcc vssx ringpll__td_pcell_45
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Mqp5 nk5 nc1 nk11 vcc plp W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc2 nk10 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqy08fal1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqy08fal1n02x5 clkb d o psb rb si ssb vcc vssx m=1
* .PININFO clkb:I d:I psb:I rb:I si:I ssb:I o:O vcc:B vssx:B
Xgd2n nk5 psb nk6 vcc vssx ringpll__na2_pcell_56
Xgd1n rb nk3 n14 nk4 vcc vssx ringpll__bo2na2_pcell_148
Xgtd2 nk4 nk5 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgtd1 n0 nk3 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xg101 nk5 o vcc vssx ringpll__inv_pcell_38
Xg11 psb n14 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgclkn clkb nc1 vcc vssx ringpll__inv_pcell_44
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_38
Xg0 n801 n0 vcc vssx ringpll__inv_pcell_38
Xgd1 nc1 nc2 nk4 nk3 vcc vssx ringpll__td_pcell_45
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_45
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_45
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Mqp5 nk5 nc1 nk11 vcc plp W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc2 nk10 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15nonb02an1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nonb02an1n02x3 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg0 a n1 vcc vssx ringpll__inv_pcell_97
Xg1 n1 b out0 vcc vssx ringpll__no2_pcell_147
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqn00cal1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn00cal1n02x3 clk d o psb vcc vssx m=1
* .PININFO clk:I d:I psb:I o:O vcc:B vssx:B
Xgd1n nk3 psb nk4 vcc vssx ringpll__na2_pcell_56
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_142
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_142
Xg0 d n0 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_145
Xg101 nk6 o vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_144
Mqp6 nk11 nk6 vcc vcc plp W=45n L=40n M=1
Mqp4 nk5 psb vcc vcc plp W=90n L=40n M=1
Mqp5 nk5 nc2 nk11 vcc plp W=45n L=40n M=1
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_146
Mqn6 nk10 nk6 nk9 vssx nlp W=45n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=45n L=40n M=1
Mqn4 nk9 psb vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqn00cal1n04x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn00cal1n04x3 clk d o psb vcc vssx m=1
* .PININFO clk:I d:I psb:I o:O vcc:B vssx:B
Xgd1n nk3 psb nk4 vcc vssx ringpll__na2_pcell_48
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_142
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_142
Xg0 d n0 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_145
Xg101 nk6 o vcc vssx ringpll__inv_pcell_36
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_144
Mqp6 nk11 nk6 vcc vcc plp W=45n L=40n M=1
Mqp4 nk5 psb vcc vcc plp W=90n L=40n M=1
Mqp5 nk5 nc2 nk11 vcc plp W=45n L=40n M=1
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_146
Mqn6 nk10 nk6 nk9 vssx nlp W=45n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=45n L=40n M=1
Mqn4 nk9 psb vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15lsn000al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15lsn000al1n02x3 clk d o vcc vssx m=1
* .PININFO clk:I d:I o:O vcc:B vssx:B
Xg1 n0 nk1 clk nc3 vcc vssx ringpll__xf_pcell_142
Xg4 nc3 clk nk2 nk1 vcc vssx ringpll__td_pcell_146
Xg0 d n0 vcc vssx ringpll__inv_pcell_38
Xg2 clk nc3 vcc vssx ringpll__inv_pcell_144
Xg99 nk1 nk2 vcc vssx ringpll__inv_pcell_143
Xg101 nk1 o vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fpn000al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fpn000al1n02x3 clk d o vcc vssx m=1
* .PININFO clk:I d:I o:O vcc:B vssx:B
Xg0 d n0 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_145
Xg101 nk6 o vcc vssx ringpll__inv_pcell_38
Xgd1n nk3 nk4 vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_144
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_142
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_142
Xgd2 nc1 nc2 nk6 nk5 vcc vssx ringpll__td_pcell_146
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_146
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqy00cal1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqy00cal1n02x3 clk d o psb si ssb vcc vssx m=1
* .PININFO clk:I d:I psb:I si:I ssb:I o:O vcc:B vssx:B
Xgd1n nk3 psb nk4 vcc vssx ringpll__na2_pcell_56
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_142
Xgtd1 n801 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_142
Mqp5 nk5 nc2 nk11 vcc plp W=45n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=45n L=40n M=1
Mqp4 nk5 psb vcc vcc plp W=90n L=40n M=1
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_45
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_45
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_146
Xg101 nk6 o vcc vssx ringpll__inv_pcell_38
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_144
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_145
Mqn6 nk10 nk6 nk9 vssx nlp W=45n L=40n M=1
Mqn4 nk9 psb vssx vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=45n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fpn040al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fpn040al1n02x3 clk d den o vcc vssx m=1
* .PININFO clk:I d:I den:I o:O vcc:B vssx:B
Xg0 n71 n0 vcc vssx ringpll__inv_pcell_38
Xg22 den n81 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_145
Xg101 nk5 o vcc vssx ringpll__inv_pcell_38
Xgd1n nk3 nk4 vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_143
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_144
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_142
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_142
Xg23 n81 den nk6 n71 vcc vssx ringpll__td_pcell_45
Xgd2 nc1 nc2 nk6 nk5 vcc vssx ringpll__td_pcell_146
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_146
Xg21 den n81 d n71 vcc vssx ringpll__td_pcell_45
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqn003al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn003al1n02x3 clk d o rb vcc vssx m=1
* .PININFO clk:I d:I rb:I o:O vcc:B vssx:B
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_56
Mqp5 nk5 nc2 nk11 vcc plp W=45n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=45n L=40n M=1
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_142
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_142
Xg0 n9 n0 vcc vssx ringpll__inv_pcell_38
Xg1 d n9 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_145
Xg101 nk5 o vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_143
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_144
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_146
Mqn6 nk10 nk6 nk9 vssx nlp W=45n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=45n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15lsn080al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15lsn080al1n02x3 clkb d o vcc vssx m=1
* .PININFO clkb:I d:I o:O vcc:B vssx:B
Xg1 n0 nk1 nc3 clkb vcc vssx ringpll__xf_pcell_142
Xg4 clkb nc3 nk2 nk1 vcc vssx ringpll__td_pcell_146
Xg0 d n0 vcc vssx ringpll__inv_pcell_38
Xg2 clkb nc3 vcc vssx ringpll__inv_pcell_145
Xg99 nk1 nk2 vcc vssx ringpll__inv_pcell_143
Xg101 nk1 o vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqn043al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn043al1n02x3 clk d den o rb vcc vssx m=1
* .PININFO clk:I d:I den:I rb:I o:O vcc:B vssx:B
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_144
Xg0 n71 n0 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_145
Xg22 den n81 vcc vssx ringpll__inv_pcell_38
Xg101 nk5 o vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_143
Mqp5 nk5 nc2 nk11 vcc plp W=45n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=45n L=40n M=1
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_142
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_142
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_56
Xg21 den n81 d n71 vcc vssx ringpll__td_pcell_45
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_146
Xg23 n81 den nk6 n71 vcc vssx ringpll__td_pcell_45
Mqn6 nk10 nk6 nk9 vssx nlp W=45n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=45n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqy003al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqy003al1n02x3 clk d o rb si ssb vcc vssx m=1
* .PININFO clk:I d:I rb:I si:I ssb:I o:O vcc:B vssx:B
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_56
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Mqp5 nk5 nc2 nk11 vcc plp W=45n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=45n L=40n M=1
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_142
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_142
Xg101 nk5 o vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_143
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_144
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_145
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_38
Xg0 n801 n0 vcc vssx ringpll__inv_pcell_38
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_146
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_45
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_45
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
Mqn6 nk10 nk6 nk9 vssx nlp W=45n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=45n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15and002ah1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002ah1n02x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_141
Xg101 n1 o vcc vssx ringpll__inv_pcell_51
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nanb02al1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nanb02al1n16x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg1 n1 b out0 vcc vssx ringpll__na2_pcell_140
Xg0 a n1 vcc vssx ringpll__inv_pcell_41
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15xor002an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xor002an1n02x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg5 a n3 vcc vssx ringpll__inv_pcell_97
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_132
Xg1 b n1 vcc vssx ringpll__inv_pcell_116
Xg2 n1 out0 a n3 vcc vssx ringpll__xf_pcell_96
Xg4 n2 out0 n3 a vcc vssx ringpll__xf_pcell_96
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15mbn022an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15mbn022an1n04x5 a b o sa vcc vssx m=1
* .PININFO a:I b:I sa:I o:O vcc:B vssx:B
Xg3 sa n2 vcc vssx ringpll__inv_pcell_97
Xg1 a n0 vcc vssx ringpll__inv_pcell_132
Xg4 b n1 vcc vssx ringpll__inv_pcell_132
Xg101 n3 o vcc vssx ringpll__inv_pcell_116
Xg5 n1 n3 n2 sa vcc vssx ringpll__xf_pcell_96
Xg2 n0 n3 sa n2 vcc vssx ringpll__xf_pcell_96
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15and002an1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002an1n03x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_95
Xg101 n1 o vcc vssx ringpll__inv_pcell_132
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15xnr002an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xnr002an1n02x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg2 n1 out0 n3 a vcc vssx ringpll__xf_pcell_96
Xg4 n2 out0 a n3 vcc vssx ringpll__xf_pcell_96
Xg1 b n1 vcc vssx ringpll__inv_pcell_116
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_132
Xg5 a n3 vcc vssx ringpll__inv_pcell_97
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_b15mdn004xl1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_b15mdn004xl1n04x5 o1 vccx vssx a b c d sa sb sc sd
* .PININFO a:I b:I c:I d:I sa:I sb:I sc:I sd:I o1:O vccx:B vssx:B
Xg11 n7 o1 sd n8 vccx vssx ringpll__xf_pcell_131
Xg2 n1 o1 sa n2 vccx vssx ringpll__xf_pcell_131
Xg5 n3 o1 sb n4 vccx vssx ringpll__xf_pcell_131
Xg8 n5 o1 sc n6 vccx vssx ringpll__xf_pcell_131
Xg10 sd n8 vccx vssx ringpll__inv_pcell_16
Xg9 d n7 vccx vssx ringpll__inv_pcell_14
Xg6 sb n4 vccx vssx ringpll__inv_pcell_16
Xg1 a n1 vccx vssx ringpll__inv_pcell_14
Xg0 sc n6 vccx vssx ringpll__inv_pcell_16
Xg3 sa n2 vccx vssx ringpll__inv_pcell_16
Xg7 c n5 vccx vssx ringpll__inv_pcell_14
Xg4 b n3 vccx vssx ringpll__inv_pcell_14
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_b15fan003xn1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_b15fan003xn1n02x5 o vccx vssx clk d rb
* .PININFO clk:I d:I rb:I o:O vccx:B vssx:B
Xgnaf nk6 rb nk9 vccx vssx ringpll__na2_pcell_130
Xgd1n nk3 rb nk4 vccx vssx ringpll__na2_pcell_130
Xgd1 nc8 nc1 nk4 nk3 vccx vssx ringpll__td_pcell_115
Xgtd2 nk4 nk5 clk nc1 vccx vssx ringpll__xf_pcell_112
Xgtd2k nk9 nk5 nc1 clk vccx vssx ringpll__xf_pcell_112
Xgtd1 d nk3 nc1 nc8 vccx vssx ringpll__xf_pcell_112
Xgclkdd nc1 nc8 vccx vssx ringpll__inv_pcell_113
Xg99 nk5 nk6 vccx vssx ringpll__inv_pcell_113
Xgclkn clk nc1 vccx vssx ringpll__inv_pcell_113
Xg101 nk5 o vccx vssx ringpll__inv_pcell_113
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljpll_cpslice
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljpll_cpslice v_dn v_up dn nbias pbias sel up vccpll vssx
* .PININFO dn:I nbias:I pbias:I sel:I up:I vccpll:I vssx:I v_dn:B v_up:B
Xinv02 dnb dnbb vccpll vssx ringpll__b15inv000an1n08x5 m=1
Xp_isource[4] vccpll v_up pbias swp ringpll__pllx22_ljpll_2pal74stack
Xp_isource[3] vccpll v_up pbias swp ringpll__pllx22_ljpll_2pal74stack
Xp_isource[2] vccpll v_up pbias swp ringpll__pllx22_ljpll_2pal74stack
Xp_isource[1] vccpll v_up pbias swp ringpll__pllx22_ljpll_2pal74stack
Xnand4 dn sel dnb vccpll vssx ringpll__b15nand02an1n08x5 m=1
Xnand1 up sel up_b vccpll vssx ringpll__b15nand02an1n08x5 m=1
Mnsw1[4] swn dnbb vssx vssx ntgmv W=270n L=120n M=1
Mnsw1[3] swn dnbb vssx vssx ntgmv W=270n L=120n M=1
Mnsw1[2] swn dnbb vssx vssx ntgmv W=270n L=120n M=1
Mnsw1[1] swn dnbb vssx vssx ntgmv W=270n L=120n M=1
Xn_isource[4] vssx v_dn nbias swn ringpll__pllx22_ljpll_2nal74stack
Xn_isource[3] vssx v_dn nbias swn ringpll__pllx22_ljpll_2nal74stack
Xn_isource[2] vssx v_dn nbias swn ringpll__pllx22_ljpll_2nal74stack
Xn_isource[1] vssx v_dn nbias swn ringpll__pllx22_ljpll_2nal74stack
Mpsw1[4] swp up_b vccpll vccpll ptgmv W=270n L=120n M=1
Mpsw1[3] swp up_b vccpll vccpll ptgmv W=270n L=120n M=1
Mpsw1[2] swp up_b vccpll vccpll ptgmv W=270n L=120n M=1
Mpsw1[1] swp up_b vccpll vccpll ptgmv W=270n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljpll_cplogic
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljpll_cplogic enbb nbias0b nbias1b nbias2b pwgb pwgbb en nbias0 nbias1 nbias2 pwg vccx vssx
* .PININFO en:I nbias0:I nbias1:I nbias2:I pwg:I vccx:I vssx:I enbb:O nbias0b:O nbias1b:O nbias2b:O pwgb:O pwgbb:O
Xnor02 enb nbias2 nbias2b vccx vssx ringpll__b15nor002al1n08x5 m=1
Xnor01 enb nbias1 nbias1b vccx vssx ringpll__b15nor002al1n04x5 m=1
Xnor00 enb nbias0 nbias0b vccx vssx ringpll__b15nor002al1n04x5 m=1
Xinv06 enb enbb vccx vssx ringpll__b15inv000al1n32x5 m=1
Xinv_cp0 en enb vccx vssx ringpll__b15inv000al1n12x5 m=1
Xinv01 pwg pwgb vccx vssx ringpll__b15inv000an1n08x5 m=1
Xinv00 pwgb pwgbb vccx vssx ringpll__b15inv000an1n32x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljpll_cpslicequarter
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljpll_cpslicequarter v_dn v_up dn nbias pbias sel up vccpll vssx
* .PININFO dn:I nbias:I pbias:I sel:I up:I vccpll:I vssx:I v_dn:B v_up:B
Mpsw1[1] swp up_b vccpll vccpll ptgmv W=135n L=120n M=1
Mpsw1[0] swp up_b vccpll vccpll ptgmv W=135n L=120n M=1
Xp_isource vccpll v_up pbias swp ringpll__pllx22_ljpll_2pal74stack_qslice
Xnand1 up sel up_b vccpll vssx ringpll__b15nand02an1n04x5 m=1
Xinv02 dnb dnbb vccpll vssx ringpll__b15inv000an1n04x5 m=1
Mnsw1[1] swn dnbb vssx vssx ntgmv W=135n L=120n M=1
Mnsw1[0] swn dnbb vssx vssx ntgmv W=135n L=120n M=1
Xn_isource vssx v_dn nbias swn ringpll__pllx22_ljpll_2nal74stack_qslice
Xnand4 dn sel dnb vccpll vssx ringpll__b15nand02an1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vcoro
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vcoro clkvco cb[2] cb[1] cb[0] vccvco vssx
* .PININFO cb[2]:I cb[1]:I cb[0]:I vccvco:I vssx:I clkvco:O
Xinv5 clkvco cb[2] cb[1] cb[0] vo4 vccvco vssx ringpll__vcorostage
Xinv4 vo4 cb[2] cb[1] cb[0] vo3 vccvco vssx ringpll__vcorostage
Xinv3 vo3 cb[2] cb[1] cb[0] vo2 vccvco vssx ringpll__vcorostage
Xinv2 vo2 cb[2] cb[1] cb[0] vo1 vccvco vssx ringpll__vcorostage
Xinv1 vo1 cb[2] cb[1] cb[0] clkvco vccvco vssx ringpll__vcorostage
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15orn003al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15orn003al1n02x5 a b c o vcc vssx m=1
* .PININFO a:I b:I c:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_38
Xg1 a b c n1 vcc vssx ringpll__no3_pcell_117
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vcoro_lj
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vcoro_lj clkvco cb[2] cb[1] cb[0] vccvco vssx
* .PININFO cb[2]:I cb[1]:I cb[0]:I vccvco:I vssx:I clkvco:O
Xinv5 clkvco cb[2] cb[1] cb[0] vo4 vccvco vssx ringpll__vcorostage_lj
Xinv4 vo4 cb[2] cb[1] cb[0] vo3 vccvco vssx ringpll__vcorostage_lj
Xinv3 vo3 cb[2] cb[1] cb[0] vo2 vccvco vssx ringpll__vcorostage_lj
Xinv2 vo2 cb[2] cb[1] cb[0] vo1 vccvco vssx ringpll__vcorostage_lj
Xinv1 vo1 cb[2] cb[1] cb[0] clkvco vccvco vssx ringpll__vcorostage_lj
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15ao0022an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ao0022an1n04x5 a b c d o vcc vssx m=1
* .PININFO a:I b:I c:I d:I o:O vcc:B vssx:B
Mqp1 n4 a n1 vcc p W=180n L=40n M=1
Mqp3 n1 c vcc vcc p W=180n L=40n M=1
Mqp4 n1 d vcc vcc p W=180n L=40n M=1
Mqp2 n4 b n1 vcc p W=180n L=40n M=1
Mqn4 n3 d vssx vssx n W=90n L=40n M=1
Mqn2 n2 b vssx vssx n W=90n L=40n M=1
Mqn1 n4 a n2 vssx n W=90n L=40n M=1
Mqn3 n4 c n3 vssx n W=90n L=40n M=1
Xg101 n4 o vcc vssx ringpll__inv_pcell_116
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15rm0023an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15rm0023an1n04x5 a b c carry sum vcc vssx m=1
* .PININFO a:I b:I c:I carry:O sum:O vcc:B vssx:B
Mqp71 n10 a n9 vcc p W=90n L=40n M=1
Mqp70 n9 b vcc vcc p W=90n L=40n M=1
Mqp72 n8 c n10 vcc p W=90n L=40n M=1
Mqp41 n8 n1 n6 vcc p W=90n L=40n M=1
Mqp40 n6 c vcc vcc p W=90n L=40n M=1
Mqp50 n6 a vcc vcc p W=90n L=40n M=1
Mqp60 n6 b vcc vcc p W=90n L=40n M=1
Mqp31 n1 b n3 vcc p W=90n L=40n M=1
Mqp30 n3 a vcc vcc p W=90n L=40n M=1
Mqp10 n0 b vcc vcc p W=90n L=40n M=1
Mqp11 n1 c n0 vcc p W=90n L=40n M=1
Mqp20 n0 a vcc vcc p W=90n L=40n M=1
Xg102 n1 carry vcc vssx ringpll__inv_pcell_116
Xg101 n8 sum vcc vssx ringpll__inv_pcell_116
Mqn31 n1 b n4 vssx n W=90n L=40n M=1
Mqn70 n12 b vssx vssx n W=90n L=40n M=1
Mqn71 n11 a n12 vssx n W=90n L=40n M=1
Mqn40 n7 c vssx vssx n W=90n L=40n M=1
Mqn50 n7 a vssx vssx n W=90n L=40n M=1
Mqn60 n7 b vssx vssx n W=90n L=40n M=1
Mqn41 n8 n1 n7 vssx n W=90n L=40n M=1
Mqn30 n4 a vssx vssx n W=90n L=40n M=1
Mqn20 n2 a vssx vssx n W=90n L=40n M=1
Mqn10 n2 b vssx vssx n W=90n L=40n M=1
Mqn11 n1 c n2 vssx n W=90n L=40n M=1
Mqn72 n8 c n11 vssx n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15aboi22an1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aboi22an1n08x5 a b c d out0 vcc vssx m=1
* .PININFO a:I b:I c:I d:I out0:O vcc:B vssx:B
Xg1 a n0 vcc vssx ringpll__inv_pcell_116
Mqn4 n3 d vssx vssx n W=360n L=40n M=1
Mqn2 n2 b vssx vssx n W=360n L=40n M=1
Mqn1 out0 n0 n2 vssx n W=360n L=40n M=1
Mqn3 out0 c n3 vssx n W=360n L=40n M=1
Mqp1 out0 n0 n1 vcc p W=360n L=40n M=1
Mqp3 n1 c vcc vcc p W=360n L=40n M=1
Mqp4 n1 d vcc vcc p W=360n L=40n M=1
Mqp2 out0 b n1 vcc p W=360n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15bfm201an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfm201an1n04x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n2 o vcc vssx ringpll__inv_pcell_116
Mqn2 n0 a vssx vssx n W=90n L=40n M=1
Mqn1 n2 a n0 vssx n W=90n L=40n M=1
Mqp2 n1 a vcc vcc p W=90n L=40n M=1
Mqp1 n2 a n1 vcc p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15bfm402an1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfm402an1n04x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg1 a n0 vcc vssx ringpll__inv_pcell_97
Xg101 n6 o vcc vssx ringpll__inv_pcell_116
Mqn4 n4 n3 vssx vssx n W=90n L=40n M=1
Mqn3 n6 n3 n4 vssx n W=90n L=40n M=1
Mqn2 n1 n0 vssx vssx n W=90n L=40n M=1
Mqn1 n3 n0 n1 vssx n W=90n L=40n M=1
Mqp4 n5 n3 vcc vcc p W=90n L=40n M=1
Mqp3 n6 n3 n5 vcc p W=90n L=40n M=1
Mqp2 n2 n0 vcc vcc p W=90n L=40n M=1
Mqp1 n3 n0 n2 vcc p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_b15fan003xn1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_b15fan003xn1n08x5 o vccx vssx clk d rb
* .PININFO clk:I d:I rb:I o:O vccx:B vssx:B
Xgnaf nk6 rb nk9 vccx vssx ringpll__na2_pcell_109
Xgd1n nk3 rb nk4 vccx vssx ringpll__na2_pcell_110
Xgtd2 nk4 nk5 clk nc1 vccx vssx ringpll__xf_pcell_111
Xgtd2k nk9 nk5 nc1 clk vccx vssx ringpll__xf_pcell_112
Xgtd1 d nk3 nc1 nc8 vccx vssx ringpll__xf_pcell_112
Xgclkdd nc1 nc8 vccx vssx ringpll__inv_pcell_113
Xg99 nk5 nk6 vccx vssx ringpll__inv_pcell_113
Xgclkn clk nc1 vccx vssx ringpll__inv_pcell_113
Xg101 nk5 o vccx vssx ringpll__inv_pcell_114
Xgd1 nc8 nc1 nk4 nk3 vccx vssx ringpll__td_pcell_115
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_b15mdn003xn1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_b15mdn003xn1n08x5 o1 vccx vssx a b c sa sb sc
* .PININFO a:I b:I c:I sa:I sb:I sc:I o1:O vccx:B vssx:B
Xg2 n1 o1 sa n2 vccx vssx ringpll__xf_pcell_106
Xg5 n3 o1 sb n4 vccx vssx ringpll__xf_pcell_106
Xg8 n5 o1 sc n6 vccx vssx ringpll__xf_pcell_106
Xg6 sb n4 vccx vssx ringpll__inv_pcell_107
Xg1[1] a n1 vccx vssx ringpll__inv_pcell_108
Xg1[0] a n1 vccx vssx ringpll__inv_pcell_108
Xg4[1] b n3 vccx vssx ringpll__inv_pcell_108
Xg4[0] b n3 vccx vssx ringpll__inv_pcell_108
Xg0 sc n6 vccx vssx ringpll__inv_pcell_107
Xg3 sa n2 vccx vssx ringpll__inv_pcell_107
Xg7[1] c n5 vccx vssx ringpll__inv_pcell_108
Xg7[0] c n5 vccx vssx ringpll__inv_pcell_108
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_b15mdn004xn1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_b15mdn004xn1n08x5 o1 vccx vssx a b c d sa sb sc sd
* .PININFO a:I b:I c:I d:I sa:I sb:I sc:I sd:I o1:O vccx:B vssx:B
Xg11 n7 o1 sd n8 vccx vssx ringpll__xf_pcell_106
Xg2 n1 o1 sa n2 vccx vssx ringpll__xf_pcell_106
Xg5 n3 o1 sb n4 vccx vssx ringpll__xf_pcell_106
Xg8 n5 o1 sc n6 vccx vssx ringpll__xf_pcell_106
Xg10 sd n8 vccx vssx ringpll__inv_pcell_107
Xg1[1] a n1 vccx vssx ringpll__inv_pcell_108
Xg1[0] a n1 vccx vssx ringpll__inv_pcell_108
Xg6 sb n4 vccx vssx ringpll__inv_pcell_107
Xg4[1] b n3 vccx vssx ringpll__inv_pcell_108
Xg4[0] b n3 vccx vssx ringpll__inv_pcell_108
Xg0 sc n6 vccx vssx ringpll__inv_pcell_107
Xg3 sa n2 vccx vssx ringpll__inv_pcell_107
Xg9[1] d n7 vccx vssx ringpll__inv_pcell_108
Xg9[0] d n7 vccx vssx ringpll__inv_pcell_108
Xg7[1] c n5 vccx vssx ringpll__inv_pcell_108
Xg7[0] c n5 vccx vssx ringpll__inv_pcell_108
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_anamux
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_anamux aout ain en vccxx vssx
* .PININFO ain:I en:I vccxx:I vssx:I aout:B
Mmp1 en_b en vccxx vccxx ptgmv W=90n L=120n M=1
Xitgate ain aout en en_b vccxx vssx ringpll__x22heldo_tgate_ll_anamux
Mmn0 en_b en vssx vssx ntgmv W=90n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22heldo_enc4to16
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22heldo_enc4to16 dmfix_out[15] dmfix_out[14] dmfix_out[13] dmfix_out[12] dmfix_out[11] dmfix_out[10] dmfix_out[9] dmfix_out[8] dmfix_out[7] dmfix_out[6] dmfix_out[5] dmfix_out[4] dmfix_out[3] dmfix_out[2] dmfix_out[1] dmfix_out[0] outb[15] outb[14] outb[13] outb[12] outb[11] outb[10] outb[9] outb[8] outb[7] outb[6] outb[5] outb[4] outb[3] outb[2] outb[1] outb[0] dmfix_in[3] dmfix_in[2] dmfix_in[1] dmfix_in[0] vccxx vssx
* .PININFO dmfix_in[3]:I dmfix_in[2]:I dmfix_in[1]:I dmfix_in[0]:I vccxx:I vssx:I dmfix_out[15]:O dmfix_out[14]:O dmfix_out[13]:O dmfix_out[12]:O
* .PININFO dmfix_out[11]:O dmfix_out[10]:O dmfix_out[9]:O dmfix_out[8]:O dmfix_out[7]:O dmfix_out[6]:O dmfix_out[5]:O dmfix_out[4]:O dmfix_out[3]:O
* .PININFO dmfix_out[2]:O dmfix_out[1]:O dmfix_out[0]:O outb[15]:O outb[14]:O outb[13]:O outb[12]:O outb[11]:O outb[10]:O outb[9]:O outb[8]:O
* .PININFO outb[7]:O outb[6]:O outb[5]:O outb[4]:O outb[3]:O outb[2]:O outb[1]:O outb[0]:O
Xinv028 n113 inb[0] vccxx vssx ringpll__b15inv000an1n32x5 m=1
Xinv029 n75 inb[1] vccxx vssx ringpll__b15inv000an1n32x5 m=1
Xinv030 n74 inb[2] vccxx vssx ringpll__b15inv000an1n32x5 m=1
Xinv031 n73 inb[3] vccxx vssx ringpll__b15inv000an1n32x5 m=1
Xinv027 n114 n73 vccxx vssx ringpll__b15inv000an1n06x5 m=1
Xinv010 n115 n74 vccxx vssx ringpll__b15inv000an1n06x5 m=1
Xinv05 n116 n75 vccxx vssx ringpll__b15inv000an1n06x5 m=1
Xinv04 n117 n113 vccxx vssx ringpll__b15inv000an1n06x5 m=1
Xinv017 outb[9] dmfix_out[9] vccxx vssx ringpll__b15inv000an1n06x5 m=1
Xinv024 outb[2] dmfix_out[2] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv023 outb[3] dmfix_out[3] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv022 outb[4] dmfix_out[4] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv021 outb[5] dmfix_out[5] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv019 outb[7] dmfix_out[7] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv020 outb[6] dmfix_out[6] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv00 dmfix_in[0] n117 vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv026 outb[0] dmfix_out[0] vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv011 outb[15] dmfix_out[15] vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv016 outb[10] dmfix_out[10] vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv03 dmfix_in[2] n115 vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv01 dmfix_in[1] n116 vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv02 dmfix_in[3] n114 vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv025 outb[1] dmfix_out[1] vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv015 outb[11] dmfix_out[11] vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv013 outb[13] dmfix_out[13] vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv012 outb[14] dmfix_out[14] vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv018 outb[8] dmfix_out[8] vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xinv014 outb[12] dmfix_out[12] vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xnand7 outb[8] vccxx vssx ind[3] inb[2] inb[1] inb[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand1 outb[14] vccxx vssx ind[3] ind[2] ind[1] inb[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand3 outb[12] vccxx vssx ind[3] ind[2] inb[1] inb[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand5 outb[10] vccxx vssx ind[3] inb[2] ind[1] inb[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand11 outb[4] vccxx vssx inb[3] ind[2] inb[1] inb[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand10 outb[5] vccxx vssx inb[3] ind[2] inb[1] ind[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand9 outb[6] vccxx vssx inb[3] ind[2] ind[1] inb[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand8 outb[7] vccxx vssx inb[3] ind[2] ind[1] ind[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand6 outb[9] vccxx vssx ind[3] inb[2] inb[1] ind[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand4 outb[11] vccxx vssx ind[3] inb[2] ind[1] ind[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand2 outb[13] vccxx vssx ind[3] ind[2] inb[1] ind[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand0 outb[15] vccxx vssx ind[3] ind[2] ind[1] ind[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand12 outb[3] vccxx vssx inb[3] inb[2] ind[1] ind[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand13 outb[2] vccxx vssx inb[3] inb[2] ind[1] inb[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand14 outb[1] vccxx vssx inb[3] inb[2] inb[1] ind[0] ringpll__pllx22_b15nand24xn1n08x5
Xnand15 outb[0] vccxx vssx inb[3] inb[2] inb[1] inb[0] ringpll__pllx22_b15nand24xn1n08x5
Xinv08 inb[1] ind[1] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv06 inb[3] ind[3] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv09 inb[0] ind[0] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv07 inb[2] ind[2] vccxx vssx ringpll__b15inv000an1n20x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15and003al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and003al1n04x5 a b c o vcc vssx m=1
* .PININFO a:I b:I c:I o:O vcc:B vssx:B
Xg1 a b c n1 vcc vssx ringpll__na3_pcell_99
Xg101 n1 o vcc vssx ringpll__inv_pcell_36
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15fqy003an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqy003an1n02x5 clk d o rb si ssb vcc vssx m=1
* .PININFO clk:I d:I rb:I si:I ssb:I o:O vcc:B vssx:B
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_95
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_96
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_96
Xg101 nk5 o vcc vssx ringpll__inv_pcell_97
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_97
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_51
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_51
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_97
Xg0 n801 n0 vcc vssx ringpll__inv_pcell_97
Mqp4 nk5 rb vcc vcc p W=90n L=40n M=1
Mqp5 nk5 nc2 nk11 vcc p W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc p W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx n W=90n L=40n M=1
Mqn6 nk10 nk6 nk9 vssx n W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx n W=90n L=40n M=1
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_98
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_98
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_98
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15cbf000an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000an1n02x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc p W=90n L=40n M=1
Mqn1 n0 clk vssx vssx n W=90n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_97
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15rm0023an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15rm0023an1n02x5 a b c carry sum vcc vssx m=1
* .PININFO a:I b:I c:I carry:O sum:O vcc:B vssx:B
Mqp71 n10 a n9 vcc p W=90n L=40n M=1
Mqp70 n9 b vcc vcc p W=90n L=40n M=1
Mqp72 n8 c n10 vcc p W=90n L=40n M=1
Mqp41 n8 n1 n6 vcc p W=90n L=40n M=1
Mqp40 n6 c vcc vcc p W=90n L=40n M=1
Mqp50 n6 a vcc vcc p W=90n L=40n M=1
Mqp60 n6 b vcc vcc p W=90n L=40n M=1
Mqp31 n1 b n3 vcc p W=90n L=40n M=1
Mqp30 n3 a vcc vcc p W=90n L=40n M=1
Mqp10 n0 b vcc vcc p W=90n L=40n M=1
Mqp11 n1 c n0 vcc p W=90n L=40n M=1
Mqp20 n0 a vcc vcc p W=90n L=40n M=1
Xg102 n1 carry vcc vssx ringpll__inv_pcell_97
Xg101 n8 sum vcc vssx ringpll__inv_pcell_97
Mqn31 n1 b n4 vssx n W=90n L=40n M=1
Mqn70 n12 b vssx vssx n W=90n L=40n M=1
Mqn71 n11 a n12 vssx n W=90n L=40n M=1
Mqn40 n7 c vssx vssx n W=90n L=40n M=1
Mqn50 n7 a vssx vssx n W=90n L=40n M=1
Mqn60 n7 b vssx vssx n W=90n L=40n M=1
Mqn41 n8 n1 n7 vssx n W=90n L=40n M=1
Mqn30 n4 a vssx vssx n W=90n L=40n M=1
Mqn20 n2 a vssx vssx n W=90n L=40n M=1
Mqn10 n2 b vssx vssx n W=90n L=40n M=1
Mqn11 n1 c n2 vssx n W=90n L=40n M=1
Mqn72 n8 c n11 vssx n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15bfm402an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfm402an1n02x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg1 a n0 vcc vssx ringpll__inv_pcell_97
Xg101 n6 o vcc vssx ringpll__inv_pcell_97
Mqn4 n4 n3 vssx vssx n W=90n L=40n M=1
Mqn3 n6 n3 n4 vssx n W=90n L=40n M=1
Mqn2 n1 n0 vssx vssx n W=90n L=40n M=1
Mqn1 n3 n0 n1 vssx n W=90n L=40n M=1
Mqp4 n5 n3 vcc vcc p W=90n L=40n M=1
Mqp3 n6 n3 n5 vcc p W=90n L=40n M=1
Mqp2 n2 n0 vcc vcc p W=90n L=40n M=1
Mqp1 n3 n0 n2 vcc p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15aboi22an1n04x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aboi22an1n04x3 a b c d out0 vcc vssx m=1
* .PININFO a:I b:I c:I d:I out0:O vcc:B vssx:B
Xg1 a n0 vcc vssx ringpll__inv_pcell_97
Mqn4 n3 d vssx vssx n W=180n L=40n M=1
Mqn2 n2 b vssx vssx n W=180n L=40n M=1
Mqn1 out0 n0 n2 vssx n W=180n L=40n M=1
Mqn3 out0 c n3 vssx n W=180n L=40n M=1
Mqp1 out0 n0 n1 vcc p W=90n L=40n M=1
Mqp3 n1 c vcc vcc p W=90n L=40n M=1
Mqp4 n1 d vcc vcc p W=90n L=40n M=1
Mqp2 out0 b n1 vcc p W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15obai22an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15obai22an1n02x5 a b c d out0 vcc vssx m=1
* .PININFO a:I b:I c:I d:I out0:O vcc:B vssx:B
Xg1 a n0 vcc vssx ringpll__inv_pcell_97
Mqn2 out0 b n1 vssx n W=90n L=40n M=1
Mqn4 n1 d vssx vssx n W=90n L=40n M=1
Mqn3 n1 c vssx vssx n W=90n L=40n M=1
Mqn1 out0 n0 n1 vssx n W=90n L=40n M=1
Mqp3 out0 c n3 vcc p W=180n L=40n M=1
Mqp1 out0 n0 n2 vcc p W=180n L=40n M=1
Mqp2 n2 b vcc vcc p W=180n L=40n M=1
Mqp4 n3 d vcc vcc p W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15mbn022an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15mbn022an1n02x5 a b o sa vcc vssx m=1
* .PININFO a:I b:I sa:I o:O vcc:B vssx:B
Xg3 sa n2 vcc vssx ringpll__inv_pcell_97
Xg1 a n0 vcc vssx ringpll__inv_pcell_97
Xg4 b n1 vcc vssx ringpll__inv_pcell_97
Xg101 n3 o vcc vssx ringpll__inv_pcell_97
Xg5 n1 n3 n2 sa vcc vssx ringpll__xf_pcell_96
Xg2 n0 n3 sa n2 vcc vssx ringpll__xf_pcell_96
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15ao0022an1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ao0022an1n02x5 a b c d o vcc vssx m=1
* .PININFO a:I b:I c:I d:I o:O vcc:B vssx:B
Mqp1 n4 a n1 vcc p W=90n L=40n M=1
Mqp3 n1 c vcc vcc p W=90n L=40n M=1
Mqp4 n1 d vcc vcc p W=90n L=40n M=1
Mqp2 n4 b n1 vcc p W=90n L=40n M=1
Mqn4 n3 d vssx vssx n W=90n L=40n M=1
Mqn2 n2 b vssx vssx n W=90n L=40n M=1
Mqn1 n4 a n2 vssx n W=90n L=40n M=1
Mqn3 n4 c n3 vssx n W=90n L=40n M=1
Xg101 n4 o vcc vssx ringpll__inv_pcell_97
.ENDS

* ***********************************************************************
*  Library Name: nn
*  Cell Name:    b15oaib12en1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oaib12en1n02x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Mqn1 out0 a n2 vssx n W=90n L=40n M=1
Mqn2 n2 b vssx vssx n W=90n L=40n M=1
Mqn3 n2 n1 vssx vssx n W=90n L=40n M=1
Mqp3 n3 n1 vcc vcc p W=90n L=40n M=1
Mqp1 out0 a vcc vcc p W=90n L=40n M=1
Mqp2 out0 b n3 vcc p W=90n L=40n M=1
Xg1 c n1 vcc vssx ringpll__inv_pcell_97
.ENDS

* ***********************************************************************
*  Library Name: gd
*  Cell Name:    b15mdn022ag1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15mdn022ag1n04x5 a_ehv b_ehv o1_ehv sa_ehv vcc_ehv vssx m=1
* .PININFO a_ehv:I b_ehv:I sa_ehv:I o1_ehv:O vcc_ehv:B vssx:B
Xg2 n0 o1_ehv sa_ehv n2 vcc_ehv vssx ringpll__xf_pcell_90
Xg5 n1 o1_ehv n2 sa_ehv vcc_ehv vssx ringpll__xf_pcell_90
Xg3 sa_ehv n2 vcc_ehv vssx ringpll__inv_pcell_91
Xg1 a_ehv n0 vcc_ehv vssx ringpll__inv_pcell_92
Xg4 b_ehv n1 vcc_ehv vssx ringpll__inv_pcell_92
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_invcsc
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_invcsc o i vccxx vssx
* .PININFO i:I vccxx:I vssx:I o:O
Xmp0 o i vccxx vccxx ringpll__p_s_pcell_88 m=1
Xmn0 o i vssx vssx ringpll__n_s_pcell_89 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_invamp
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_invamp o en_b i vbias vccxx vssx
* .PININFO en_b:I i:I vbias:I vccxx:I vssx:I o:O
Mmp0 psrc en_b vccxx vccxx p W=180n L=40n M=4
Mmp3 o vbias nsp vccxx p W=180n L=40n M=13
Mmp2 nsp i np3 vccxx p W=180n L=40n M=5
Xmp1 np3 i psrc vccxx ringpll__p_s_pcell_87 m=1
Xmn3 o en_b vssx vssx ringpll__n_s_pcell_89 m=1
Xmn0 nn3 i vssx vssx ringpll__n_s_pcell_86 m=1
Mmn2 o vbias nsn vssx n W=180n L=40n M=13
Mmn1 nsn i nn3 vssx n W=180n L=40n M=5
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_invamp_biasgen
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_invamp_biasgen vbias_a en_b vccxx vssx
* .PININFO en_b:I vccxx:I vssx:I vbias_a:O
Xmn0[1] vbias_a vbias_a vssx vssx ringpll__n_s_pcell_86 m=1
Xmn0[0] vbias_a vbias_a vssx vssx ringpll__n_s_pcell_86 m=1
Mmp1 net12 en_b vccxx vccxx p W=180n L=40n M=2
Xmp0[1] vbias_a vbias_a net12 vccxx ringpll__p_s_pcell_87 m=1
Xmp0[0] vbias_a vbias_a net12 vccxx ringpll__p_s_pcell_87 m=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15and003al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and003al1n03x5 a b c o vcc vssx m=1
* .PININFO a:I b:I c:I o:O vcc:B vssx:B
Xg1 a b c n1 vcc vssx ringpll__na3_pcell_85
Xg101 n1 o vcc vssx ringpll__inv_pcell_46
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15and003al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and003al1n02x5 a b c o vcc vssx m=1
* .PININFO a:I b:I c:I o:O vcc:B vssx:B
Xg1 a b c n1 vcc vssx ringpll__na3_pcell_84
Xg101 n1 o vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15clbia2al1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15clbia2al1n16x5 clk clkout force0b vcc vssx m=1
* .PININFO clk:I force0b:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plp W=180n L=40n M=1
Mqp2 n0 force0b vcc vcc plp W=135n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_83
Mqn1 n0 clk n1 vssx nlp W=270n L=40n M=1
Mqn2 n1 force0b vssx vssx nlp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15cbf000al1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000al1n16x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plp W=180n L=40n M=1
Mqn1 n0 clk vssx vssx nlp W=225n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_83
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqn003al1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn003al1n06x5 clk d o rb vcc vssx m=1
* .PININFO clk:I d:I rb:I o:O vcc:B vssx:B
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_82
Mqp5 nk5 nc2 nk11 vcc plp W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_61
Xg0 n9 n0 vcc vssx ringpll__inv_pcell_46
Xg1 d n9 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Xg101 nk5 o vcc vssx ringpll__inv_pcell_43
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15and002al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002al1n08x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_82
Xg101 n1 o vcc vssx ringpll__inv_pcell_41
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15and002al1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002al1n16x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_81
Xg101 n1 o vcc vssx ringpll__inv_pcell_71
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15mbc024el1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15mbc024el1n08x5 a b c d o sa sb vcc vssx m=1
* .PININFO a:I b:I c:I d:I sa:I sb:I o:O vcc:B vssx:B
Xg6 n1 n3 sb n2 vcc vssx ringpll__xf_pcell_47
Xg5 n0 n3 n2 sb vcc vssx ringpll__xf_pcell_47
Xg101 n3 o vcc vssx ringpll__inv_pcell_41
Xg4 sb n2 vcc vssx ringpll__inv_pcell_38
Xg0 sa n4 vcc vssx ringpll__inv_pcell_36
Xg2 c n4 d sa n1 vcc vssx ringpll__b2a2no2_pcell_80
Xg1 a n4 b sa n0 vcc vssx ringpll__b2a2no2_pcell_80
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15bfn001ah1n24x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn001ah1n24x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Mqn1 n1 a vssx vssx nlvt W=540n L=40n M=1
Mqp1 n1 a vcc vcc plvt W=540n L=40n M=1
Xg101 n1 o vcc vssx ringpll__inv_pcell_77
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_lsin_bar
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_lsin_bar out0b in0 vcc_in vcc_out vssx
* .PININFO in0:I vcc_in:I vcc_out:I vssx:I out0b:O
Xinv00 n1 out0b vcc_out vssx ringpll__b15inv000al1n24x5 m=1
Xsg000 in0 n1 vcc_in vcc_out vssx ringpll__b15sg00ndal1d04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_nolsin_bar
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_nolsin_bar out0b in0 vccx vssx
* .PININFO in0:I vccx:I vssx:I out0b:O
Xinv00 in0 out0b vccx vssx ringpll__b15inv000al1n24x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nonb02al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nonb02al1n02x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg0 a n1 vcc vssx ringpll__inv_pcell_38
Xg1 n1 b out0 vcc vssx ringpll__no2_pcell_76
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15orn002al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15orn002al1n03x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_46
Xg1 a b n1 vcc vssx ringpll__no2_pcell_76
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oab012al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oab012al1n02x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg1 a n1 out0 vcc vssx ringpll__no2_pcell_76
Xg0 b c n1 vcc vssx ringpll__no2_pcell_55
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfn001al1n24x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn001al1n24x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Mqn1 n1 a vssx vssx nlp W=540n L=40n M=1
Mqp1 n1 a vcc vcc plp W=540n L=40n M=1
Xg101 n1 o vcc vssx ringpll__inv_pcell_75
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfn000al1n24x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn000al1n24x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_75
Mqn1 n1 a vssx vssx nlp W=270n L=40n M=1
Mqp1 n1 a vcc vcc plp W=270n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15fqn003ah1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn003ah1n08x5 clk d o rb vcc vssx m=1
* .PININFO clk:I d:I rb:I o:O vcc:B vssx:B
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_74
Mqp5 nk5 nc2 nk11 vcc plvt W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plvt W=90n L=40n M=1
Mqp4 nk5 rb vcc vcc plvt W=90n L=40n M=1
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_73
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_70
Xg0 n9 n0 vcc vssx ringpll__inv_pcell_69
Xg1 d n9 vcc vssx ringpll__inv_pcell_51
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_68
Xg101 nk5 o vcc vssx ringpll__inv_pcell_52
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_51
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_51
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_67
Mqn6 nk10 nk6 nk9 vssx nlvt W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlvt W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx nlvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15nanb02ah1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nanb02ah1n08x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg1 n1 b out0 vcc vssx ringpll__na2_pcell_74
Xg0 a n1 vcc vssx ringpll__inv_pcell_69
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15xor002ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xor002ah1n03x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg5 a n3 vcc vssx ringpll__inv_pcell_51
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_69
Xg1 b n1 vcc vssx ringpll__inv_pcell_57
Xg2 n1 out0 a n3 vcc vssx ringpll__xf_pcell_73
Xg4 n2 out0 n3 a vcc vssx ringpll__xf_pcell_73
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15xnr002ah1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xnr002ah1n03x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg2 n1 out0 n3 a vcc vssx ringpll__xf_pcell_73
Xg4 n2 out0 a n3 vcc vssx ringpll__xf_pcell_73
Xg1 b n1 vcc vssx ringpll__inv_pcell_57
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_69
Xg5 a n3 vcc vssx ringpll__inv_pcell_51
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15xor002al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xor002al1n08x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg5 a n3 vcc vssx ringpll__inv_pcell_36
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_6
Xg1 b n1 vcc vssx ringpll__inv_pcell_71
Xg2 n1 out0 a n3 vcc vssx ringpll__xf_pcell_72
Xg4 n2 out0 n3 a vcc vssx ringpll__xf_pcell_72
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15xnr002al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xnr002al1n08x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg2 n1 out0 n3 a vcc vssx ringpll__xf_pcell_72
Xg4 n2 out0 a n3 vcc vssx ringpll__xf_pcell_72
Xg1 b n1 vcc vssx ringpll__inv_pcell_71
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_6
Xg5 a n3 vcc vssx ringpll__inv_pcell_36
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfm402al1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfm402al1n16x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg1 a n0 vcc vssx ringpll__inv_pcell_38
Xg101 n6 o vcc vssx ringpll__inv_pcell_71
Mqn4 n4 n3 vssx vssx nlp W=180n L=40n M=1
Mqn3 n6 n3 n4 vssx nlp W=180n L=40n M=1
Mqn2 n1 n0 vssx vssx nlp W=90n L=40n M=1
Mqn1 n3 n0 n1 vssx nlp W=90n L=40n M=1
Mqp4 n5 n3 vcc vcc plp W=180n L=40n M=1
Mqp3 n6 n3 n5 vcc plp W=180n L=40n M=1
Mqp2 n2 n0 vcc vcc plp W=90n L=40n M=1
Mqp1 n3 n0 n2 vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15xor002ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xor002ah1n04x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg5 a n3 vcc vssx ringpll__inv_pcell_51
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_57
Xg1 b n1 vcc vssx ringpll__inv_pcell_52
Xg2 n1 out0 a n3 vcc vssx ringpll__xf_pcell_70
Xg4 n2 out0 n3 a vcc vssx ringpll__xf_pcell_70
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15ao0022ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ao0022ah1n04x5 a b c d o vcc vssx m=1
* .PININFO a:I b:I c:I d:I o:O vcc:B vssx:B
Mqn4 n3 d vssx vssx nlvt W=90n L=40n M=1
Mqn2 n2 b vssx vssx nlvt W=90n L=40n M=1
Mqn1 n4 a n2 vssx nlvt W=90n L=40n M=1
Mqn3 n4 c n3 vssx nlvt W=90n L=40n M=1
Mqp1 n4 a n1 vcc plvt W=180n L=40n M=1
Mqp3 n1 c vcc vcc plvt W=180n L=40n M=1
Mqp4 n1 d vcc vcc plvt W=180n L=40n M=1
Mqp2 n4 b n1 vcc plvt W=180n L=40n M=1
Xg101 n4 o vcc vssx ringpll__inv_pcell_69
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15lsn080ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15lsn080ah1n04x5 clkb d o vcc vssx m=1
* .PININFO clkb:I d:I o:O vcc:B vssx:B
Xg1 n0 nk1 nc3 clkb vcc vssx ringpll__xf_pcell_66
Xg4 clkb nc3 nk2 nk1 vcc vssx ringpll__td_pcell_67
Xg0 d n0 vcc vssx ringpll__inv_pcell_68
Xg2 clkb nc3 vcc vssx ringpll__inv_pcell_51
Xg99 nk1 nk2 vcc vssx ringpll__inv_pcell_51
Xg101 nk1 o vcc vssx ringpll__inv_pcell_69
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15bfm201ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfm201ah1n04x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n2 o vcc vssx ringpll__inv_pcell_69
Mqn2 n0 a vssx vssx nlvt W=90n L=40n M=1
Mqn1 n2 a n0 vssx nlvt W=90n L=40n M=1
Mqp2 n1 a vcc vcc plvt W=90n L=40n M=1
Mqp1 n2 a n1 vcc plvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cbf000ah1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000ah1n04x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plvt W=90n L=40n M=1
Mqn1 n0 clk vssx vssx nlvt W=135n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_69
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15mbn022ah1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15mbn022ah1n08x5 a b o sa vcc vssx m=1
* .PININFO a:I b:I sa:I o:O vcc:B vssx:B
Xg3 sa n2 vcc vssx ringpll__inv_pcell_51
Xg1 a n0 vcc vssx ringpll__inv_pcell_69
Xg4 b n1 vcc vssx ringpll__inv_pcell_69
Xg101 n3 o vcc vssx ringpll__inv_pcell_52
Xg5 n1 n3 n2 sa vcc vssx ringpll__xf_pcell_66
Xg2 n0 n3 sa n2 vcc vssx ringpll__xf_pcell_66
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    cpaclkphdelana
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__cpaclkphdelana clkoutb clkin cueh rst vccx vssx
* .PININFO clkin:I cueh:I rst:I vccx:I vssx:I clkoutb:O
Xnan0 t0b t1 rst t0 vccx vssx ringpll__b15nor003ah1n03x5 m=1
Xnon0 t1b t0 rst t1 vccx vssx ringpll__b15nor003ah1n03x5 m=1
Xkan0 rstb s0b clkinb t0 s0 vccx vssx ringpll__b15aoai13ah1n03x5 m=1
Xi16 t0b s1b cueh t0 vccx vssx ringpll__pll_divkon02
Xikon2 t1b s0b cueh t1 vccx vssx ringpll__pll_divkon02
Xinv06 clkinb clkind vccx vssx ringpll__b15inv000ah1n16x5 m=1
Xinv04 clkin clkinb vccx vssx ringpll__b15inv000ah1n20x5 m=1
Xpgcd[1] clkind clkoutb sel1 sel1b vccx vssx ringpll__xf_pcell_65
Xpgcd[0] clkind clkoutb sel1 sel1b vccx vssx ringpll__xf_pcell_65
Xpgcb[1] clkinb clkoutb sel0 sel0b vccx vssx ringpll__xf_pcell_65
Xpgcb[0] clkinb clkoutb sel0 sel0b vccx vssx ringpll__xf_pcell_65
Xcan1 s0 clkinb s1b t1 s0b vccx vssx ringpll__b15aoi013ah1n03x5 m=1
Xcan4 s1 clkind s0b t0 s1b vccx vssx ringpll__b15aoi013ah1n03x5 m=1
Xcan5 rst t0b t1b s1b rstb vccx vssx ringpll__b15aoi013ah1n03x5 m=1
Xinv03 s1 sel1b vccx vssx ringpll__b15inv000ah1n04x5 m=1
Xinv02 s0 sel0b vccx vssx ringpll__b15inv000ah1n04x5 m=1
Xinv05 sel0b sel0 vccx vssx ringpll__b15inv000ah1n04x5 m=1
Xinv07 sel1b sel1 vccx vssx ringpll__b15inv000ah1n04x5 m=1
Xkan1 s1b rst clkind t1 s1 vccx vssx ringpll__b15aoi112ah1n03x5 m=1
Mpcba vccx sel1 pux vccx plvt W=180n L=40n M=1
Mpcbb pux sel0 clkoutb vccx plvt W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fmy203al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fmy203al1n04x5 clk d o rb si ssb vcc vssx m=1
* .PININFO clk:I d:I rb:I si:I ssb:I o:O vcc:B vssx:B
Xg20 nk8 nk5 nc1 nc91 vcc vssx ringpll__xf_pcell_60
Xg4 nk14 nk15 clk nc11 vcc vssx ringpll__xf_pcell_37
Xg2 n17 nk13 nc11 nc12 vcc vssx ringpll__xf_pcell_61
Xg14 nk4 nk5 nc91 nc1 vcc vssx ringpll__xf_pcell_61
Xg10 nk18 nk15 nc11 clk vcc vssx ringpll__xf_pcell_37
Xg12 n801 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_61
Xg28 rb n92 vcc vssx ringpll__inv_pcell_43
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_38
Xg5 nk15 n19 vcc vssx ringpll__inv_pcell_38
Xg101 n19 o vcc vssx ringpll__inv_pcell_36
Xg15 nk5 n9 vcc vssx ringpll__inv_pcell_38
Xg99 nk15 nk16 vcc vssx ringpll__inv_pcell_38
Xg17 nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xg7 nc11 nc12 vcc vssx ringpll__inv_pcell_44
Xg23 nc90 nc91 vcc vssx ringpll__inv_pcell_62
Xg16 nc91 nc1 vcc vssx ringpll__inv_pcell_63
Xg24 clk nc90 vcc vssx ringpll__inv_pcell_44
Xg1 n10 n17 vcc vssx ringpll__inv_pcell_43
Xg6 clk nc11 vcc vssx ringpll__inv_pcell_62
Xg22 n9 n10 vcc vssx ringpll__inv_pcell_38
Xg21 nk5 nk6 vcc vssx ringpll__inv_pcell_43
Xg19 nk6 n92 nk8 vcc vssx ringpll__no2_pcell_7
Xg18 nk3 n92 nk4 vcc vssx ringpll__no2_pcell_7
Xg8 nk13 n92 nk14 vcc vssx ringpll__no2_pcell_7
Xg9 nk16 n92 nk18 vcc vssx ringpll__no2_pcell_55
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_45
Xg13 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_64
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_64
Xg3 nc12 nc11 nk14 nk13 vcc vssx ringpll__td_pcell_64
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fmy200al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fmy200al1n04x5 clk d o si ssb vcc vssx m=1
* .PININFO clk:I d:I si:I ssb:I o:O vcc:B vssx:B
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_38
Xg99 nk15 nk16 vcc vssx ringpll__inv_pcell_38
Xg101 n19 o vcc vssx ringpll__inv_pcell_36
Xg15 nk5 n9 vcc vssx ringpll__inv_pcell_38
Xg24 clk nc90 vcc vssx ringpll__inv_pcell_44
Xg19 nk13 nk14 vcc vssx ringpll__inv_pcell_43
Xg1 n10 n17 vcc vssx ringpll__inv_pcell_43
Xg5 nk15 n19 vcc vssx ringpll__inv_pcell_38
Xg7 nc11 nc12 vcc vssx ringpll__inv_pcell_44
Xg23 nc90 nc91 vcc vssx ringpll__inv_pcell_62
Xg6 clk nc11 vcc vssx ringpll__inv_pcell_62
Xg11 nk3 nk4 vcc vssx ringpll__inv_pcell_43
Xg16 nc91 nc1 vcc vssx ringpll__inv_pcell_63
Xg22 n9 n10 vcc vssx ringpll__inv_pcell_38
Xg17 nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xg21 nk5 nk6 vcc vssx ringpll__inv_pcell_43
Xg3 nc12 nc11 nk14 nk13 vcc vssx ringpll__td_pcell_64
Xg18 nc1 nc91 nk6 nk5 vcc vssx ringpll__td_pcell_64
Xg13 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_64
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_64
Xg20 nc11 clk nk16 nk15 vcc vssx ringpll__td_pcell_45
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_45
Xg12 n801 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_61
Xg14 nk4 nk5 nc91 nc1 vcc vssx ringpll__xf_pcell_61
Xg2 n17 nk13 nc11 nc12 vcc vssx ringpll__xf_pcell_61
Xg4 nk14 nk15 clk nc11 vcc vssx ringpll__xf_pcell_37
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqn003al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn003al1n08x5 clk d o rb vcc vssx m=1
* .PININFO clk:I d:I rb:I o:O vcc:B vssx:B
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_24
Mqp5 nk5 nc2 nk11 vcc plp W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_61
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_47
Xg0 n9 n0 vcc vssx ringpll__inv_pcell_36
Xg1 d n9 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_62
Xg101 nk5 o vcc vssx ringpll__inv_pcell_41
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15xnr002al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xnr002al1n03x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg2 n1 out0 n3 a vcc vssx ringpll__xf_pcell_61
Xg4 n2 out0 a n3 vcc vssx ringpll__xf_pcell_61
Xg1 b n1 vcc vssx ringpll__inv_pcell_43
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_36
Xg5 a n3 vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15xor002al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xor002al1n03x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg5 a n3 vcc vssx ringpll__inv_pcell_38
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_36
Xg1 b n1 vcc vssx ringpll__inv_pcell_43
Xg2 n1 out0 a n3 vcc vssx ringpll__xf_pcell_61
Xg4 n2 out0 n3 a vcc vssx ringpll__xf_pcell_61
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cbf000ah1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000ah1n12x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plvt W=180n L=40n M=1
Mqn1 n0 clk vssx vssx nlvt W=225n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_59
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cmbn22ah1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cmbn22ah1n12x5 clk1 clk2 clkout s vcc vssx m=1
* .PININFO clk1:I clk2:I s:I clkout:O vcc:B vssx:B
Xg4 n2 n3 n4 s vcc vssx ringpll__xf_pcell_58
Xg2 n1 n3 s n4 vcc vssx ringpll__xf_pcell_58
Xg201 n3 clkout vcc vssx ringpll__inv_pcell_59
Xg6 s n4 vcc vssx ringpll__inv_pcell_51
Xg3 clk2 n2 vcc vssx ringpll__inv_pcell_57
Xg1 clk1 n1 vcc vssx ringpll__inv_pcell_57
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15clb0a2ah1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15clb0a2ah1n06x5 clk clkout en vcc vssx m=1
* .PININFO clk:I en:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plvt W=90n L=40n M=1
Mqp2 n0 en vcc vcc plvt W=90n L=40n M=1
Mqn1 n0 clk n1 vssx nlvt W=180n L=40n M=1
Mqn2 n1 en vssx vssx nlvt W=180n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_57
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15bfn001ah1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn001ah1n06x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Mqn1 n1 a vssx vssx nlvt W=135n L=40n M=1
Mqp1 n1 a vcc vcc plvt W=135n L=40n M=1
Xg101 n1 o vcc vssx ringpll__inv_pcell_57
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15aob012al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aob012al1n03x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg0 b c n1 vcc vssx ringpll__na2_pcell_56
Xg1 a n1 out0 vcc vssx ringpll__na2_pcell_48
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nanb02al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nanb02al1n02x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg1 n1 b out0 vcc vssx ringpll__na2_pcell_56
Xg0 a n1 vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15and002al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002al1n02x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_56
Xg101 n1 o vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15naoai3el1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15naoai3el1n02x5 a b c d out0 vcc vssx m=1
* .PININFO a:I b:I c:I d:I out0:O vcc:B vssx:B
Mqn1 out0 n1 n2 vssx nlp W=90n L=40n M=1
Mqn2 n2 c vssx vssx nlp W=90n L=40n M=1
Mqn3 n2 d vssx vssx nlp W=90n L=40n M=1
Xg1 a b n1 vcc vssx ringpll__na2_pcell_56
Mqp3 n3 d vcc vcc plp W=90n L=40n M=1
Mqp1 out0 n1 vcc vcc plp W=90n L=40n M=1
Mqp2 out0 c n3 vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15ornc04al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ornc04al1n02x5 a b c d o vcc vssx m=1
* .PININFO a:I b:I c:I d:I o:O vcc:B vssx:B
Xg1 c d n1 vcc vssx ringpll__no2_pcell_55
Xg0 a b n0 vcc vssx ringpll__no2_pcell_55
Xg2 n0 n1 o vcc vssx ringpll__na2_pcell_56
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15orn002al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15orn002al1n02x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_38
Xg1 a b n1 vcc vssx ringpll__no2_pcell_55
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nonb02al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nonb02al1n02x3 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg0 a n1 vcc vssx ringpll__inv_pcell_38
Xg1 n1 b out0 vcc vssx ringpll__no2_pcell_55
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15ornc04al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ornc04al1n03x5 a b c d o vcc vssx m=1
* .PININFO a:I b:I c:I d:I o:O vcc:B vssx:B
Xg1 c d n1 vcc vssx ringpll__no2_pcell_55
Xg0 a b n0 vcc vssx ringpll__no2_pcell_55
Xg2 n0 n1 o vcc vssx ringpll__na2_pcell_48
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_clk_ls
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_clk_ls out0 clk en vcc_in vcc_out vssx
* .PININFO clk:I en:I vcc_in:I vcc_out:I vssx:I out0:O
Mmn13 n6match n4match vssx vssx n W=180n L=40n M=1
Mmn11 n2 n3 vssx vssx n W=180n L=40n M=3
Mmn14 n3match n2match n6match vssx n W=90n L=40n M=1
Mmn10 n3 n4 vssx vssx n W=45n L=40n M=5
Mmn8 net40 n2 vssx vssx n W=135n L=40n M=3
Mmn1 out0 net40 vssx vssx n W=90n L=40n M=1
Mmn9 n3 n2 vssx vssx n W=45n L=40n M=5
Mmn3 ob net40 vssx vssx n W=180n L=40n M=1
Mmn0 out0 net40 vssx vssx n W=135n L=40n M=3
Mmn2 net40 enb vssx vssx n W=90n L=40n M=1
Mmn5 n8match ob n9match vssx n W=90n L=40n M=1
Mmn4 net40 ob n8match vssx n W=90n L=40n M=1
Mmn15 n2match n3match n7match vssx n W=45n L=40n M=15
Mmn6 n9match n2match vssx vssx n W=90n L=40n M=1
Mmn12 n2 clk vssx vssx n W=90n L=40n M=1
Mmn7 net40 n2 vssx vssx n W=90n L=40n M=1
Mmn16 n7match clk vssx vssx n W=45n L=40n M=15
Xg3 en enb vcc_out vssx ringpll__inv_pcell_53
Xg4 clk n4 vcc_in vssx ringpll__inv_pcell_53
Xg5 clk n4match vcc_in vssx ringpll__inv_pcell_53
Mmp16 n2match n3match vxxout_pg_nom vxxout_pg_nom p W=135n L=40n M=1
Mmp4 n9 n2 vxxout_pg_nom vxxout_pg_nom p W=90n L=40n M=1
Mmp18 n3match n4match vxxout_pg_nom vxxout_pg_nom p W=225n L=40n M=1
Mmp10 n3 n2 n6 vxxout_pg_nom p W=90n L=40n M=1
Mmp9 n6 n4 vxxout_pg_nom vxxout_pg_nom p W=90n L=40n M=1
Mmp14 n3match n4match vxxout_pg_nom vxxout_pg_nom p W=180n L=40n M=1
Mmp8 vxxout_pg_nom enb vcc_out vcc_out p W=180n L=40n M=15
Mmp3 net40 n2match vxxout_pg_nom vxxout_pg_nom p W=90n L=40n M=1
Mmp5 n8 ob n9 vxxout_pg_nom p W=90n L=40n M=1
Mmp13 n3match n2match vxxout_pg_nom vxxout_pg_nom p W=135n L=40n M=1
Mmp0 out0 net40 vcc_out vcc_out p W=135n L=40n M=3
Mmp6 net40 ob n8 vxxout_pg_nom p W=90n L=40n M=1
Mmp7 ob net40 vxxout_pg_nom vxxout_pg_nom p W=180n L=40n M=1
Mmp2 net40 n2match vxxout_pg_nom vxxout_pg_nom p W=135n L=40n M=3
Mmp15 n2match clk vxxout_pg_nom vxxout_pg_nom p W=360n L=40n M=1
Mmp12 n2 n3 n7 vxxout_pg_nom p W=45n L=40n M=15
Mmp1 out0 net40 vcc_out vcc_out p W=90n L=40n M=1
Mmp11 n7 clk vxxout_pg_nom vxxout_pg_nom p W=45n L=40n M=9
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_pllcolthenc
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_pllcolthenc o[6] o[5] o[4] o[3] o[2] o[1] o[0] i[2] i[1] i[0] vccxx vssx
* .PININFO i[2]:I i[1]:I i[0]:I vccxx:I vssx:I o[6]:O o[5]:O o[4]:O o[3]:O o[2]:O o[1]:O o[0]:O
Xii1 i[2] ob_3 vccxx vssx ringpll__b15inv000an1n06x5 m=1
Xii0 i[1] ob_1 vccxx vssx ringpll__b15inv000an1n02x5 m=1
Xiio3 ob_3 o[3] vccxx vssx ringpll__b15inv000an1n02x5 m=1
Xi36 net10 ob_3 o[2] vccxx vssx ringpll__b15nand02an1n03x5 m=1
Xinao1 ob_1 ob_3 o[1] vccxx vssx ringpll__b15nand02an1n03x5 m=1
Xinao0 net5 ob_3 o[0] vccxx vssx ringpll__b15nand02an1n03x5 m=1
Xina i[1] i[0] net10 vccxx vssx ringpll__b15nand02an1n03x5 m=1
Xinoo5 ob_1 ob_3 o[5] vccxx vssx ringpll__b15nor002an1n03x5 m=1
Xinoo6 net10 ob_3 o[6] vccxx vssx ringpll__b15nor002an1n03x5 m=1
Xinoo4 net5 ob_3 o[4] vccxx vssx ringpll__b15nor002an1n03x5 m=1
Xino i[1] i[0] net5 vccxx vssx ringpll__b15nor002an1n03x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_pllcolestun18
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_pllcolestun18 ob tieup cb[1] cb[0] enpd enpub i nca[4] nca[3] nca[2] nca[1] nca[0] ncb[4] ncb[3] ncb[2] ncb[1] ncb[0] ncc[4] ncc[3] ncc[2] ncc[1] ncc[0] pca[4] pca[3] pca[2] pca[1] pca[0] pcb[4] pcb[3] pcb[2] pcb[1] pcb[0] pcc[4] pcc[3] pcc[2] pcc[1] pcc[0] vccxx vssx
* .PININFO cb[1]:I cb[0]:I enpd:I enpub:I i:I nca[4]:I nca[3]:I nca[2]:I nca[1]:I nca[0]:I ncb[4]:I ncb[3]:I ncb[2]:I ncb[1]:I ncb[0]:I ncc[4]:I
* .PININFO ncc[3]:I ncc[2]:I ncc[1]:I ncc[0]:I pca[4]:I pca[3]:I pca[2]:I pca[1]:I pca[0]:I pcb[4]:I pcb[3]:I pcb[2]:I pcb[1]:I pcb[0]:I pcc[4]:I
* .PININFO pcc[3]:I pcc[2]:I pcc[1]:I pcc[0]:I vccxx:I vssx:I ob:O tieup:O
Mmn0[3] vvss enpub vssx vssx nlvt W=135n L=40n M=1
Mmn0[2] vvss enpub vssx vssx nlvt W=135n L=40n M=1
Mmn0[1] vvss enpub vssx vssx nlvt W=135n L=40n M=1
Mmn0[0] vvss enpub vssx vssx nlvt W=135n L=40n M=1
Mmn2[0] vgnd nc[0] vssx vssx nlvt W=135n L=40n M=1
Mmn7[17] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[16] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[15] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[14] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[13] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[12] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[11] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[10] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[9] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[8] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[7] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[6] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[5] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[4] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[3] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[2] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[1] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn7[0] ob i vgnd vssx nlvt W=135n L=40n M=1
Mmn8[21] vssx vssx vgnd vssx nlvt W=135n L=40n M=1
Mmn8[20] vssx vssx vgnd vssx nlvt W=135n L=40n M=1
Mmn8[19] vssx vssx vgnd vssx nlvt W=135n L=40n M=1
Mmn8[18] vssx vssx vgnd vssx nlvt W=135n L=40n M=1
Mmn9[1] ob cb[1] cbl1 vssx nlvt W=135n L=40n M=1
Mmn9[0] ob cb[1] cbl1 vssx nlvt W=135n L=40n M=1
Mmn10 vssx cbl1 vssx vssx nlvt W=315n L=40n M=1
Mmn3[1] vgnd nc[1] vssx vssx nlvt W=135n L=40n M=1
Mmn3[0] vgnd nc[1] vssx vssx nlvt W=135n L=40n M=1
Mmn4[1] vgnd nc[2] vssx vssx nlvt W=135n L=40n M=1
Mmn4[0] vgnd nc[2] vssx vssx nlvt W=135n L=40n M=1
Mmn5[4] vgnd nc[3] vssx vssx nlvt W=135n L=40n M=1
Mmn5[3] vgnd nc[3] vssx vssx nlvt W=135n L=40n M=1
Mmn5[2] vgnd nc[3] vssx vssx nlvt W=135n L=40n M=1
Mmn5[1] vgnd nc[3] vssx vssx nlvt W=135n L=40n M=1
Mmn5[0] vgnd nc[3] vssx vssx nlvt W=135n L=40n M=1
Mmn6[14] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[13] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[12] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[11] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[10] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[9] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[8] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[7] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[6] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[5] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[4] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[3] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[2] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[1] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn6[0] vgnd nc[4] vssx vssx nlvt W=135n L=40n M=1
Mmn1[4] vgnd enpd vssx vssx nlvt W=135n L=40n M=1
Mmn1[3] vgnd enpd vssx vssx nlvt W=135n L=40n M=1
Mmn1[2] vgnd enpd vssx vssx nlvt W=135n L=40n M=1
Mmn1[1] vgnd enpd vssx vssx nlvt W=135n L=40n M=1
Mmn1[0] vgnd enpd vssx vssx nlvt W=135n L=40n M=1
Mmn11 vssx cbl0 vssx vssx nlvt W=135n L=40n M=1
Mmn12[1] ob cb[0] cbl0 vssx nlvt W=135n L=40n M=1
Mmn12[0] ob cb[0] cbl0 vssx nlvt W=135n L=40n M=1
Mmn13[1] cbb[1] cb[1] vssx vssx nlvt W=135n L=40n M=1
Mmn13[0] cbb[1] cb[1] vssx vssx nlvt W=135n L=40n M=1
Mmn14[1] cbb[0] cb[0] vssx vssx nlvt W=135n L=40n M=1
Mmn14[0] cbb[0] cb[0] vssx vssx nlvt W=135n L=40n M=1
Mmp9 vccxx cbl1 vccxx vccxx plvt W=360n L=40n M=1
Mmp0[4] vvss enpub vccxx vccxx plvt W=135n L=40n M=1
Mmp0[3] vvss enpub vccxx vccxx plvt W=135n L=40n M=1
Mmp0[2] vvss enpub vccxx vccxx plvt W=135n L=40n M=1
Mmp0[1] vvss enpub vccxx vccxx plvt W=135n L=40n M=1
Mmp0[0] vvss enpub vccxx vccxx plvt W=135n L=40n M=1
Mmp16[17] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[16] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[15] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[14] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[13] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[12] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[11] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[10] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[9] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[8] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[7] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[6] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[5] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[4] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[3] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[2] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[1] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp16[0] vvss i ob vccxx plvt W=135n L=40n M=1
Mmp15[21] vvss vccxx vccxx vccxx plvt W=135n L=40n M=1
Mmp15[20] vvss vccxx vccxx vccxx plvt W=135n L=40n M=1
Mmp15[19] vvss vccxx vccxx vccxx plvt W=135n L=40n M=1
Mmp15[18] vvss vccxx vccxx vccxx plvt W=135n L=40n M=1
Mmp1[3] vgnd enpd vccxx vccxx plvt W=135n L=40n M=1
Mmp1[2] vgnd enpd vccxx vccxx plvt W=135n L=40n M=1
Mmp1[1] vgnd enpd vccxx vccxx plvt W=135n L=40n M=1
Mmp1[0] vgnd enpd vccxx vccxx plvt W=135n L=40n M=1
Mmp5[1] vvss pc[1] vccxx vccxx plvt W=135n L=40n M=1
Mmp5[0] vvss pc[1] vccxx vccxx plvt W=135n L=40n M=1
Mmp6[1] vvss pc[2] vccxx vccxx plvt W=135n L=40n M=1
Mmp6[0] vvss pc[2] vccxx vccxx plvt W=135n L=40n M=1
Mmp7[4] vvss pc[3] vccxx vccxx plvt W=135n L=40n M=1
Mmp7[3] vvss pc[3] vccxx vccxx plvt W=135n L=40n M=1
Mmp7[2] vvss pc[3] vccxx vccxx plvt W=135n L=40n M=1
Mmp7[1] vvss pc[3] vccxx vccxx plvt W=135n L=40n M=1
Mmp7[0] vvss pc[3] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[14] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[13] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[12] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[11] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[10] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[9] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[8] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[7] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[6] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[5] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[4] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[3] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[2] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[1] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp8[0] vvss pc[4] vccxx vccxx plvt W=135n L=40n M=1
Mmp11[1] vccxx cb[0] cbb[0] vccxx plvt W=135n L=40n M=1
Mmp11[0] vccxx cb[0] cbb[0] vccxx plvt W=135n L=40n M=1
Mmp13[1] vccxx cb[1] cbb[1] vccxx plvt W=135n L=40n M=1
Mmp13[0] vccxx cb[1] cbb[1] vccxx plvt W=135n L=40n M=1
Mmp10 vccxx cbl0 vccxx vccxx plvt W=135n L=40n M=1
Mmp12[1] cbl0 cbb[0] ob vccxx plvt W=135n L=40n M=1
Mmp12[0] cbl0 cbb[0] ob vccxx plvt W=135n L=40n M=1
Mmp14[1] cbl1 cbb[1] ob vccxx plvt W=135n L=40n M=1
Mmp14[0] cbl1 cbb[1] ob vccxx plvt W=135n L=40n M=1
Mmp2[1] tieup vssx vccxx vccxx plvt W=135n L=40n M=1
Mmp2[0] tieup vssx vccxx vccxx plvt W=135n L=40n M=1
Mmp3[0] vvss pc[0] vccxx vccxx plvt W=135n L=40n M=1
Xiaoi[5] pc[4] pca[4] pcb[4] pcc[4] vccxx vssx ringpll__pll_pllcolesaoi
Xiaoi[4] pc[4] pca[4] pcb[4] pcc[4] vccxx vssx ringpll__pll_pllcolesaoi
Xiaoi[3] pc[3] pca[3] pcb[3] pcc[3] vccxx vssx ringpll__pll_pllcolesaoi
Xiaoi[2] pc[2] pca[2] pcb[2] pcc[2] vccxx vssx ringpll__pll_pllcolesaoi
Xiaoi[1] pc[1] pca[1] pcb[1] pcc[1] vccxx vssx ringpll__pll_pllcolesaoi
Xiaoi[0] pc[0] pca[0] pcb[0] pcc[0] vccxx vssx ringpll__pll_pllcolesaoi
Xioai[5] nc[4] nca[4] ncb[4] ncc[4] vccxx vssx ringpll__pll_pllcolesoai
Xioai[4] nc[4] nca[4] ncb[4] ncc[4] vccxx vssx ringpll__pll_pllcolesoai
Xioai[3] nc[3] nca[3] ncb[3] ncc[3] vccxx vssx ringpll__pll_pllcolesoai
Xioai[2] nc[2] nca[2] ncb[2] ncc[2] vccxx vssx ringpll__pll_pllcolesoai
Xioai[1] nc[1] nca[1] ncb[1] ncc[1] vccxx vssx ringpll__pll_pllcolesoai
Xioai[0] nc[0] nca[0] ncb[0] ncc[0] vccxx vssx ringpll__pll_pllcolesoai
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cmbn22ah1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cmbn22ah1n16x5 clk1 clk2 clkout s vcc vssx m=1
* .PININFO clk1:I clk2:I s:I clkout:O vcc:B vssx:B
Xg4 n2 n3 n4 s vcc vssx ringpll__xf_pcell_49
Xg2 n1 n3 s n4 vcc vssx ringpll__xf_pcell_49
Xg201 n3 clkout vcc vssx ringpll__inv_pcell_50
Xg6 s n4 vcc vssx ringpll__inv_pcell_51
Xg3 clk2 n2 vcc vssx ringpll__inv_pcell_52
Xg1 clk1 n1 vcc vssx ringpll__inv_pcell_52
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cbf000ah1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000ah1n08x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plvt W=90n L=40n M=1
Mqn1 n0 clk vssx vssx nlvt W=135n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_52
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15ao0022ah1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ao0022ah1n02x5 a b c d o vcc vssx m=1
* .PININFO a:I b:I c:I d:I o:O vcc:B vssx:B
Mqn4 n3 d vssx vssx nlvt W=90n L=40n M=1
Mqn2 n2 b vssx vssx nlvt W=90n L=40n M=1
Mqn1 n4 a n2 vssx nlvt W=90n L=40n M=1
Mqn3 n4 c n3 vssx nlvt W=90n L=40n M=1
Mqp1 n4 a n1 vcc plvt W=90n L=40n M=1
Mqp3 n1 c vcc vcc plvt W=90n L=40n M=1
Mqp4 n1 d vcc vcc plvt W=90n L=40n M=1
Mqp2 n4 b n1 vcc plvt W=90n L=40n M=1
Xg101 n4 o vcc vssx ringpll__inv_pcell_51
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15oaib12eh1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oaib12eh1n02x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Mqn1 out0 a n2 vssx nlvt W=90n L=40n M=1
Mqn2 n2 b vssx vssx nlvt W=90n L=40n M=1
Mqn3 n2 n1 vssx vssx nlvt W=90n L=40n M=1
Xg1 c n1 vcc vssx ringpll__inv_pcell_51
Mqp3 n3 n1 vcc vcc plvt W=90n L=40n M=1
Mqp1 out0 a vcc vcc plvt W=90n L=40n M=1
Mqp2 out0 b n3 vcc plvt W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cbf000ah1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000ah1n02x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plvt W=90n L=40n M=1
Mqn1 n0 clk vssx vssx nlvt W=90n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_51
.ENDS

* ***********************************************************************
*  Library Name: hn
*  Cell Name:    b15cbf000ah1n16x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000ah1n16x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plvt W=180n L=40n M=1
Mqn1 n0 clk vssx vssx nlvt W=225n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_50
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqn043al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn043al1n02x5 clk d den o rb vcc vssx m=1
* .PININFO clk:I d:I den:I rb:I o:O vcc:B vssx:B
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xg0 n71 n0 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Xg22 den n81 vcc vssx ringpll__inv_pcell_38
Xg101 nk5 o vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Mqp5 nk5 nc2 nk11 vcc plp W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_48
Xg21 den n81 d n71 vcc vssx ringpll__td_pcell_45
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
Xg23 n81 den nk6 n71 vcc vssx ringpll__td_pcell_45
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqy003al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqy003al1n02x5 clk d o rb si ssb vcc vssx m=1
* .PININFO clk:I d:I rb:I si:I ssb:I o:O vcc:B vssx:B
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_48
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Mqp5 nk5 nc2 nk11 vcc plp W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xg101 nk5 o vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_38
Xg0 n801 n0 vcc vssx ringpll__inv_pcell_38
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_45
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_45
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15and002al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002al1n03x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_48
Xg101 n1 o vcc vssx ringpll__inv_pcell_46
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqy043al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqy043al1n02x5 clk d den o rb si ssb vcc vssx m=1
* .PININFO clk:I d:I den:I rb:I si:I ssb:I o:O vcc:B vssx:B
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Mqp5 nk5 nc2 nk11 vcc plp W=90n L=40n M=1
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Xg901 n71 n801 ssb n800 vcc vssx ringpll__xf_pcell_37
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_48
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_45
Xg23 n81 den nk6 n71 vcc vssx ringpll__td_pcell_45
Xg21 den n81 d n71 vcc vssx ringpll__td_pcell_45
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
Xg22 den n81 vcc vssx ringpll__inv_pcell_38
Xg101 nk5 o vcc vssx ringpll__inv_pcell_38
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xg0 n801 n0 vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqn003al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn003al1n02x5 clk d o rb vcc vssx m=1
* .PININFO clk:I d:I rb:I o:O vcc:B vssx:B
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_48
Mqp5 nk5 nc2 nk11 vcc plp W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xg0 n9 n0 vcc vssx ringpll__inv_pcell_38
Xg1 d n9 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Xg101 nk5 o vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_lfmux
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_lfmux aout ain shortb vccxx vssx
* .PININFO ain:I shortb:I vccxx:I vssx:I aout:B
Mmp0 ain enb aout vccxx plvt W=360n L=40n M=16
Xinv02 shortb en vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv00 en enb vccxx vssx ringpll__b15inv000al1n02x5 m=1
Mmn0 ain en aout vssx nlvt W=180n L=40n M=16
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15cmbn22al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cmbn22al1n08x5 clk1 clk2 clkout s vcc vssx m=1
* .PININFO clk1:I clk2:I s:I clkout:O vcc:B vssx:B
Xg4 n2 n3 n4 s vcc vssx ringpll__xf_pcell_47
Xg2 n1 n3 s n4 vcc vssx ringpll__xf_pcell_47
Xg201 n3 clkout vcc vssx ringpll__inv_pcell_41
Xg6 s n4 vcc vssx ringpll__inv_pcell_38
Xg3 clk2 n2 vcc vssx ringpll__inv_pcell_36
Xg1 clk1 n1 vcc vssx ringpll__inv_pcell_36
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15mdn022al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15mdn022al1n04x5 a b o1 sa vcc vssx m=1
* .PININFO a:I b:I sa:I o1:O vcc:B vssx:B
Xg2 n0 o1 sa n2 vcc vssx ringpll__xf_pcell_47
Xg5 n1 o1 n2 sa vcc vssx ringpll__xf_pcell_47
Xg3 sa n2 vcc vssx ringpll__inv_pcell_38
Xg1 a n0 vcc vssx ringpll__inv_pcell_43
Xg4 b n1 vcc vssx ringpll__inv_pcell_43
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15xnr002al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xnr002al1n02x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg2 n1 out0 n3 a vcc vssx ringpll__xf_pcell_37
Xg4 n2 out0 a n3 vcc vssx ringpll__xf_pcell_37
Xg1 b n1 vcc vssx ringpll__inv_pcell_36
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_46
Xg5 a n3 vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15xor002al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xor002al1n02x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg5 a n3 vcc vssx ringpll__inv_pcell_38
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_46
Xg1 b n1 vcc vssx ringpll__inv_pcell_36
Xg2 n1 out0 a n3 vcc vssx ringpll__xf_pcell_37
Xg4 n2 out0 n3 a vcc vssx ringpll__xf_pcell_37
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15mbn022al1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15mbn022al1n06x5 a b o sa vcc vssx m=1
* .PININFO a:I b:I sa:I o:O vcc:B vssx:B
Xg3 sa n2 vcc vssx ringpll__inv_pcell_38
Xg1 a n0 vcc vssx ringpll__inv_pcell_46
Xg4 b n1 vcc vssx ringpll__inv_pcell_46
Xg101 n3 o vcc vssx ringpll__inv_pcell_43
Xg5 n1 n3 n2 sa vcc vssx ringpll__xf_pcell_37
Xg2 n0 n3 sa n2 vcc vssx ringpll__xf_pcell_37
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fpn040al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fpn040al1n04x5 clk d den o vcc vssx m=1
* .PININFO clk:I d:I den:I o:O vcc:B vssx:B
Xg0 n71 n0 vcc vssx ringpll__inv_pcell_38
Xg22 den n81 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Xg101 nk5 o vcc vssx ringpll__inv_pcell_36
Xgd1n nk3 nk4 vcc vssx ringpll__inv_pcell_46
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xg23 n81 den nk6 n71 vcc vssx ringpll__td_pcell_45
Xgd2 nc1 nc2 nk6 nk5 vcc vssx ringpll__td_pcell_45
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
Xg21 den n81 d n71 vcc vssx ringpll__td_pcell_45
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15mbn022al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15mbn022al1n04x5 a b o sa vcc vssx m=1
* .PININFO a:I b:I sa:I o:O vcc:B vssx:B
Xg3 sa n2 vcc vssx ringpll__inv_pcell_38
Xg1 a n0 vcc vssx ringpll__inv_pcell_46
Xg4 b n1 vcc vssx ringpll__inv_pcell_46
Xg101 n3 o vcc vssx ringpll__inv_pcell_36
Xg5 n1 n3 n2 sa vcc vssx ringpll__xf_pcell_37
Xg2 n0 n3 sa n2 vcc vssx ringpll__xf_pcell_37
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fpn000al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fpn000al1n08x5 clk d o vcc vssx m=1
* .PININFO clk:I d:I o:O vcc:B vssx:B
Xg0 d n0 vcc vssx ringpll__inv_pcell_46
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Xg101 nk6 o vcc vssx ringpll__inv_pcell_41
Xgd1n nk3 nk4 vcc vssx ringpll__inv_pcell_46
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_36
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgd2 nc1 nc2 nk6 nk5 vcc vssx ringpll__td_pcell_45
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15lsn080al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15lsn080al1n04x5 clkb d o vcc vssx m=1
* .PININFO clkb:I d:I o:O vcc:B vssx:B
Xg1 n0 nk1 nc3 clkb vcc vssx ringpll__xf_pcell_37
Xg4 clkb nc3 nk2 nk1 vcc vssx ringpll__td_pcell_45
Xg0 d n0 vcc vssx ringpll__inv_pcell_46
Xg2 clkb nc3 vcc vssx ringpll__inv_pcell_44
Xg99 nk1 nk2 vcc vssx ringpll__inv_pcell_38
Xg101 nk1 o vcc vssx ringpll__inv_pcell_36
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fpn000al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fpn000al1n04x5 clk d o vcc vssx m=1
* .PININFO clk:I d:I o:O vcc:B vssx:B
Xg0 d n0 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Xg101 nk6 o vcc vssx ringpll__inv_pcell_36
Xgd1n nk3 nk4 vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_46
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgd2 nc1 nc2 nk6 nk5 vcc vssx ringpll__td_pcell_45
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15mdn022al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15mdn022al1n02x5 a b o1 sa vcc vssx m=1
* .PININFO a:I b:I sa:I o1:O vcc:B vssx:B
Xg2 n0 o1 sa n2 vcc vssx ringpll__xf_pcell_37
Xg5 n1 o1 n2 sa vcc vssx ringpll__xf_pcell_37
Xg3 sa n2 vcc vssx ringpll__inv_pcell_38
Xg1 a n0 vcc vssx ringpll__inv_pcell_46
Xg4 b n1 vcc vssx ringpll__inv_pcell_46
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfn000al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn000al1n03x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_46
Mqn1 n1 a vssx vssx nlp W=90n L=40n M=1
Mqp1 n1 a vcc vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15ao0022al1n03x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ao0022al1n03x3 a b c d o vcc vssx m=1
* .PININFO a:I b:I c:I d:I o:O vcc:B vssx:B
Mqn4 n3 d vssx vssx nlp W=90n L=40n M=1
Mqn2 n2 b vssx vssx nlp W=90n L=40n M=1
Mqn1 n4 a n2 vssx nlp W=90n L=40n M=1
Mqn3 n4 c n3 vssx nlp W=90n L=40n M=1
Mqp1 n4 a n1 vcc plp W=90n L=40n M=1
Mqp3 n1 c vcc vcc plp W=90n L=40n M=1
Mqp4 n1 d vcc vcc plp W=90n L=40n M=1
Mqp2 n4 b n1 vcc plp W=90n L=40n M=1
Xg101 n4 o vcc vssx ringpll__inv_pcell_46
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqy003al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqy003al1n04x5 clk d o rb si ssb vcc vssx m=1
* .PININFO clk:I d:I rb:I si:I ssb:I o:O vcc:B vssx:B
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_35
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Mqp5 nk5 nc2 nk11 vcc plp W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xg101 nk5 o vcc vssx ringpll__inv_pcell_36
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_38
Xg0 n801 n0 vcc vssx ringpll__inv_pcell_38
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_45
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_45
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fqn043al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fqn043al1n04x5 clk d den o rb vcc vssx m=1
* .PININFO clk:I d:I den:I rb:I o:O vcc:B vssx:B
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
Xg0 n71 n0 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Xg22 den n81 vcc vssx ringpll__inv_pcell_38
Xg101 nk5 o vcc vssx ringpll__inv_pcell_36
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Mqp5 nk5 nc2 nk11 vcc plp W=90n L=40n M=1
Mqp6 nk11 nk6 vcc vcc plp W=90n L=40n M=1
Mqp4 nk5 rb vcc vcc plp W=90n L=40n M=1
Xgtd1 n0 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xgd1n nk3 rb nk4 vcc vssx ringpll__na2_pcell_35
Xg21 den n81 d n71 vcc vssx ringpll__td_pcell_45
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
Xg23 n81 den nk6 n71 vcc vssx ringpll__td_pcell_45
Mqn6 nk10 nk6 nk9 vssx nlp W=90n L=40n M=1
Mqn5 nk5 nc1 nk10 vssx nlp W=90n L=40n M=1
Mqn4 nk9 rb vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15fpy000al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15fpy000al1n02x5 clk d o si ssb vcc vssx m=1
* .PININFO clk:I d:I si:I ssb:I o:O vcc:B vssx:B
Xg901 ssb n800 d n801 vcc vssx ringpll__td_pcell_45
Xg801 n800 ssb si n801 vcc vssx ringpll__td_pcell_45
Xgd2 nc1 nc2 nk6 nk5 vcc vssx ringpll__td_pcell_45
Xgd1 nc2 nc1 nk4 nk3 vcc vssx ringpll__td_pcell_45
Xgtd1 n801 nk3 nc1 nc2 vcc vssx ringpll__xf_pcell_37
Xgtd2 nk4 nk5 nc2 nc1 vcc vssx ringpll__xf_pcell_37
Xg800 ssb n800 vcc vssx ringpll__inv_pcell_38
Xgclkn clk nc1 vcc vssx ringpll__inv_pcell_44
Xg101 nk6 o vcc vssx ringpll__inv_pcell_38
Xgd2n nk5 nk6 vcc vssx ringpll__inv_pcell_38
Xgd1n nk3 nk4 vcc vssx ringpll__inv_pcell_38
Xgclkdd nc1 nc2 vcc vssx ringpll__inv_pcell_44
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15lyn003al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15lyn003al1n04x5 clk d o rb vcc vssx m=1
* .PININFO clk:I d:I rb:I o:O vcc:B vssx:B
Mqp4 nk1 rb vcc vcc plp W=90n L=40n M=1
Mqp5 nk1 clk n11 vcc plp W=90n L=40n M=1
Mqp6 n11 nk2 vcc vcc plp W=90n L=40n M=1
Xg1 n0 nk1 clk nc3 vcc vssx ringpll__xf_pcell_37
Xg0 d rb n0 vcc vssx ringpll__na2_pcell_35
Mqn6 n10 nk2 n9 vssx nlp W=90n L=40n M=1
Mqn5 nk1 nc3 n10 vssx nlp W=90n L=40n M=1
Mqn4 n9 rb vssx vssx nlp W=90n L=40n M=1
Xg101 nk1 o vcc vssx ringpll__inv_pcell_36
Xg99 nk1 nk2 vcc vssx ringpll__inv_pcell_38
Xg2 clk nc3 vcc vssx ringpll__inv_pcell_44
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfn000al1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn000al1n06x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_43
Mqn1 n1 a vssx vssx nlp W=90n L=40n M=1
Mqp1 n1 a vcc vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15clb0a2al1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15clb0a2al1n06x5 clk clkout en vcc vssx m=1
* .PININFO clk:I en:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plp W=90n L=40n M=1
Mqp2 n0 en vcc vcc plp W=90n L=40n M=1
Mqn1 n0 clk n1 vssx nlp W=180n L=40n M=1
Mqn2 n1 en vssx vssx nlp W=180n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_43
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15cbf000al1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000al1n06x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plp W=90n L=40n M=1
Mqn1 n0 clk vssx vssx nlp W=135n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_43
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfn001al1n06x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn001al1n06x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Mqn1 n1 a vssx vssx nlp W=135n L=40n M=1
Mqp1 n1 a vcc vcc plp W=135n L=40n M=1
Xg101 n1 o vcc vssx ringpll__inv_pcell_43
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15orn002al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15orn002al1n08x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_41
Xg1 a b n1 vcc vssx ringpll__no2_pcell_42
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfn000al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn000al1n08x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_41
Mqn1 n1 a vssx vssx nlp W=90n L=40n M=1
Mqp1 n1 a vcc vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfm201al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfm201al1n08x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n2 o vcc vssx ringpll__inv_pcell_41
Mqn2 n0 a vssx vssx nlp W=90n L=40n M=1
Mqn1 n2 a n0 vssx nlp W=90n L=40n M=1
Mqp2 n1 a vcc vcc plp W=90n L=40n M=1
Mqp1 n2 a n1 vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15cbf000al1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000al1n08x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plp W=90n L=40n M=1
Mqn1 n0 clk vssx vssx nlp W=135n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_41
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15orn002al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15orn002al1n04x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_36
Xg1 a b n1 vcc vssx ringpll__no2_pcell_39
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15cmbn22al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cmbn22al1n04x5 clk1 clk2 clkout s vcc vssx m=1
* .PININFO clk1:I clk2:I s:I clkout:O vcc:B vssx:B
Xg4 n2 n3 n4 s vcc vssx ringpll__xf_pcell_37
Xg2 n1 n3 s n4 vcc vssx ringpll__xf_pcell_37
Xg201 n3 clkout vcc vssx ringpll__inv_pcell_36
Xg6 s n4 vcc vssx ringpll__inv_pcell_38
Xg3 clk2 n2 vcc vssx ringpll__inv_pcell_38
Xg1 clk1 n1 vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oaib12el1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oaib12el1n02x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Mqn1 out0 a n2 vssx nlp W=90n L=40n M=1
Mqn2 n2 b vssx vssx nlp W=90n L=40n M=1
Mqn3 n2 n1 vssx vssx nlp W=90n L=40n M=1
Xg1 c n1 vcc vssx ringpll__inv_pcell_38
Mqp3 n3 n1 vcc vcc plp W=90n L=40n M=1
Mqp1 out0 a vcc vcc plp W=90n L=40n M=1
Mqp2 out0 b n3 vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oa0022al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oa0022al1n02x5 a b c d o vcc vssx m=1
* .PININFO a:I b:I c:I d:I o:O vcc:B vssx:B
Xg101 n4 o vcc vssx ringpll__inv_pcell_38
Mqp3 n4 c n3 vcc plp W=90n L=40n M=1
Mqp1 n4 a n2 vcc plp W=90n L=40n M=1
Mqp2 n2 b vcc vcc plp W=90n L=40n M=1
Mqp4 n3 d vcc vcc plp W=90n L=40n M=1
Mqn2 n4 b n1 vssx nlp W=90n L=40n M=1
Mqn4 n1 d vssx vssx nlp W=90n L=40n M=1
Mqn3 n1 c vssx vssx nlp W=90n L=40n M=1
Mqn1 n4 a n1 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15ao0022al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ao0022al1n02x5 a b c d o vcc vssx m=1
* .PININFO a:I b:I c:I d:I o:O vcc:B vssx:B
Mqn4 n3 d vssx vssx nlp W=90n L=40n M=1
Mqn2 n2 b vssx vssx nlp W=90n L=40n M=1
Mqn1 n4 a n2 vssx nlp W=90n L=40n M=1
Mqn3 n4 c n3 vssx nlp W=90n L=40n M=1
Mqp1 n4 a n1 vcc plp W=90n L=40n M=1
Mqp3 n1 c vcc vcc plp W=90n L=40n M=1
Mqp4 n1 d vcc vcc plp W=90n L=40n M=1
Mqp2 n4 b n1 vcc plp W=90n L=40n M=1
Xg101 n4 o vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfm201al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfm201al1n02x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n2 o vcc vssx ringpll__inv_pcell_38
Mqn2 n0 a vssx vssx nlp W=90n L=40n M=1
Mqn1 n2 a n0 vssx nlp W=90n L=40n M=1
Mqp2 n1 a vcc vcc plp W=90n L=40n M=1
Mqp1 n2 a n1 vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfm402al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfm402al1n02x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg1 a n0 vcc vssx ringpll__inv_pcell_38
Xg101 n6 o vcc vssx ringpll__inv_pcell_38
Mqn4 n4 n3 vssx vssx nlp W=90n L=40n M=1
Mqn3 n6 n3 n4 vssx nlp W=90n L=40n M=1
Mqn2 n1 n0 vssx vssx nlp W=90n L=40n M=1
Mqn1 n3 n0 n1 vssx nlp W=90n L=40n M=1
Mqp4 n5 n3 vcc vcc plp W=90n L=40n M=1
Mqp3 n6 n3 n5 vcc plp W=90n L=40n M=1
Mqp2 n2 n0 vcc vcc plp W=90n L=40n M=1
Mqp1 n3 n0 n2 vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oabi12al1n03x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oabi12al1n03x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Mqn1 out0 n0 n1 vssx nlp W=135n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=135n L=40n M=1
Mqn3 n1 c vssx vssx nlp W=135n L=40n M=1
Xg1 a n0 vcc vssx ringpll__inv_pcell_38
Mqp3 n2 c vcc vcc plp W=135n L=40n M=1
Mqp1 out0 n0 vcc vcc plp W=90n L=40n M=1
Mqp2 out0 b n2 vcc plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15nanb02al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15nanb02al1n04x5 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg1 n1 b out0 vcc vssx ringpll__na2_pcell_35
Xg0 a n1 vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15mbn022al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15mbn022al1n02x5 a b o sa vcc vssx m=1
* .PININFO a:I b:I sa:I o:O vcc:B vssx:B
Xg3 sa n2 vcc vssx ringpll__inv_pcell_38
Xg1 a n0 vcc vssx ringpll__inv_pcell_38
Xg4 b n1 vcc vssx ringpll__inv_pcell_38
Xg101 n3 o vcc vssx ringpll__inv_pcell_38
Xg5 n1 n3 n2 sa vcc vssx ringpll__xf_pcell_37
Xg2 n0 n3 sa n2 vcc vssx ringpll__xf_pcell_37
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfm402al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfm402al1n04x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg1 a n0 vcc vssx ringpll__inv_pcell_38
Xg101 n6 o vcc vssx ringpll__inv_pcell_36
Mqn4 n4 n3 vssx vssx nlp W=90n L=40n M=1
Mqn3 n6 n3 n4 vssx nlp W=90n L=40n M=1
Mqn2 n1 n0 vssx vssx nlp W=90n L=40n M=1
Mqn1 n3 n0 n1 vssx nlp W=90n L=40n M=1
Mqp4 n5 n3 vcc vcc plp W=90n L=40n M=1
Mqp3 n6 n3 n5 vcc plp W=90n L=40n M=1
Mqp2 n2 n0 vcc vcc plp W=90n L=40n M=1
Mqp1 n3 n0 n2 vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfn000al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn000al1n02x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_38
Mqn1 n1 a vssx vssx nlp W=90n L=40n M=1
Mqp1 n1 a vcc vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15xor002al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15xor002al1n02x3 a b out0 vcc vssx m=1
* .PININFO a:I b:I out0:O vcc:B vssx:B
Xg5 a n3 vcc vssx ringpll__inv_pcell_38
Xg3 n1 n2 vcc vssx ringpll__inv_pcell_38
Xg1 b n1 vcc vssx ringpll__inv_pcell_38
Xg2 n1 out0 a n3 vcc vssx ringpll__xf_pcell_37
Xg4 n2 out0 n3 a vcc vssx ringpll__xf_pcell_37
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15rm0023al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15rm0023al1n02x5 a b c carry sum vcc vssx m=1
* .PININFO a:I b:I c:I carry:O sum:O vcc:B vssx:B
Mqp71 n10 a n9 vcc plp W=90n L=40n M=1
Mqp70 n9 b vcc vcc plp W=90n L=40n M=1
Mqp72 n8 c n10 vcc plp W=90n L=40n M=1
Mqp41 n8 n1 n6 vcc plp W=90n L=40n M=1
Mqp40 n6 c vcc vcc plp W=90n L=40n M=1
Mqp50 n6 a vcc vcc plp W=90n L=40n M=1
Mqp60 n6 b vcc vcc plp W=90n L=40n M=1
Mqp31 n1 b n3 vcc plp W=90n L=40n M=1
Mqp30 n3 a vcc vcc plp W=90n L=40n M=1
Mqp10 n0 b vcc vcc plp W=90n L=40n M=1
Mqp11 n1 c n0 vcc plp W=90n L=40n M=1
Mqp20 n0 a vcc vcc plp W=90n L=40n M=1
Xg102 n1 carry vcc vssx ringpll__inv_pcell_38
Xg101 n8 sum vcc vssx ringpll__inv_pcell_38
Mqn31 n1 b n4 vssx nlp W=90n L=40n M=1
Mqn70 n12 b vssx vssx nlp W=90n L=40n M=1
Mqn71 n11 a n12 vssx nlp W=90n L=40n M=1
Mqn40 n7 c vssx vssx nlp W=90n L=40n M=1
Mqn50 n7 a vssx vssx nlp W=90n L=40n M=1
Mqn60 n7 b vssx vssx nlp W=90n L=40n M=1
Mqn41 n8 n1 n7 vssx nlp W=90n L=40n M=1
Mqn30 n4 a vssx vssx nlp W=90n L=40n M=1
Mqn20 n2 a vssx vssx nlp W=90n L=40n M=1
Mqn10 n2 b vssx vssx nlp W=90n L=40n M=1
Mqn11 n1 c n2 vssx nlp W=90n L=40n M=1
Mqn72 n8 c n11 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15aobi12al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aobi12al1n02x3 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Xg1 a n0 vcc vssx ringpll__inv_pcell_38
Mqp3 n1 c vcc vcc plp W=90n L=40n M=1
Mqp2 n1 b vcc vcc plp W=90n L=40n M=1
Mqp1 out0 n0 n1 vcc plp W=90n L=40n M=1
Mqn3 n2 c vssx vssx nlp W=90n L=40n M=1
Mqn2 out0 b n2 vssx nlp W=90n L=40n M=1
Mqn1 out0 n0 vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oabi12al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oabi12al1n02x5 a b c out0 vcc vssx m=1
* .PININFO a:I b:I c:I out0:O vcc:B vssx:B
Mqn1 out0 n0 n1 vssx nlp W=90n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=90n L=40n M=1
Mqn3 n1 c vssx vssx nlp W=90n L=40n M=1
Xg1 a n0 vcc vssx ringpll__inv_pcell_38
Mqp3 n2 c vcc vcc plp W=90n L=40n M=1
Mqp1 out0 n0 vcc vcc plp W=90n L=40n M=1
Mqp2 out0 b n2 vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15oa0012al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15oa0012al1n02x5 a b c o vcc vssx m=1
* .PININFO a:I b:I c:I o:O vcc:B vssx:B
Xg101 n3 o vcc vssx ringpll__inv_pcell_38
Mqp3 n2 c vcc vcc plp W=90n L=40n M=1
Mqp1 n3 a vcc vcc plp W=90n L=40n M=1
Mqp2 n3 b n2 vcc plp W=90n L=40n M=1
Mqn1 n3 a n1 vssx nlp W=90n L=40n M=1
Mqn2 n1 b vssx vssx nlp W=90n L=40n M=1
Mqn3 n1 c vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15ao0012al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ao0012al1n02x5 a b c o vcc vssx m=1
* .PININFO a:I b:I c:I o:O vcc:B vssx:B
Xg101 n3 o vcc vssx ringpll__inv_pcell_38
Mqp3 n1 c vcc vcc plp W=90n L=40n M=1
Mqp2 n1 b vcc vcc plp W=90n L=40n M=1
Mqp1 n3 a n1 vcc plp W=90n L=40n M=1
Mqn3 n2 c vssx vssx nlp W=90n L=40n M=1
Mqn2 n3 b n2 vssx nlp W=90n L=40n M=1
Mqn1 n3 a vssx vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15aboi22al1n02x3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15aboi22al1n02x3 a b c d out0 vcc vssx m=1
* .PININFO a:I b:I c:I d:I out0:O vcc:B vssx:B
Xg1 a n0 vcc vssx ringpll__inv_pcell_38
Mqp1 out0 n0 n1 vcc plp W=90n L=40n M=1
Mqp3 n1 c vcc vcc plp W=90n L=40n M=1
Mqp4 n1 d vcc vcc plp W=90n L=40n M=1
Mqp2 out0 b n1 vcc plp W=90n L=40n M=1
Mqn4 n3 d vssx vssx nlp W=90n L=40n M=1
Mqn2 n2 b vssx vssx nlp W=90n L=40n M=1
Mqn1 out0 n0 n2 vssx nlp W=90n L=40n M=1
Mqn3 out0 c n3 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15cmbn22al1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cmbn22al1n02x5 clk1 clk2 clkout s vcc vssx m=1
* .PININFO clk1:I clk2:I s:I clkout:O vcc:B vssx:B
Xg4 n2 n3 n4 s vcc vssx ringpll__xf_pcell_37
Xg2 n1 n3 s n4 vcc vssx ringpll__xf_pcell_37
Xg201 n3 clkout vcc vssx ringpll__inv_pcell_38
Xg6 s n4 vcc vssx ringpll__inv_pcell_38
Xg3 clk2 n2 vcc vssx ringpll__inv_pcell_38
Xg1 clk1 n1 vcc vssx ringpll__inv_pcell_38
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15rm0023al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15rm0023al1n04x5 a b c carry sum vcc vssx m=1
* .PININFO a:I b:I c:I carry:O sum:O vcc:B vssx:B
Mqp71 n10 a n9 vcc plp W=90n L=40n M=1
Mqp70 n9 b vcc vcc plp W=90n L=40n M=1
Mqp72 n8 c n10 vcc plp W=90n L=40n M=1
Mqp41 n8 n1 n6 vcc plp W=90n L=40n M=1
Mqp40 n6 c vcc vcc plp W=90n L=40n M=1
Mqp50 n6 a vcc vcc plp W=90n L=40n M=1
Mqp60 n6 b vcc vcc plp W=90n L=40n M=1
Mqp31 n1 b n3 vcc plp W=90n L=40n M=1
Mqp30 n3 a vcc vcc plp W=90n L=40n M=1
Mqp10 n0 b vcc vcc plp W=90n L=40n M=1
Mqp11 n1 c n0 vcc plp W=90n L=40n M=1
Mqp20 n0 a vcc vcc plp W=90n L=40n M=1
Xg102 n1 carry vcc vssx ringpll__inv_pcell_36
Xg101 n8 sum vcc vssx ringpll__inv_pcell_36
Mqn31 n1 b n4 vssx nlp W=90n L=40n M=1
Mqn70 n12 b vssx vssx nlp W=90n L=40n M=1
Mqn71 n11 a n12 vssx nlp W=90n L=40n M=1
Mqn40 n7 c vssx vssx nlp W=90n L=40n M=1
Mqn50 n7 a vssx vssx nlp W=90n L=40n M=1
Mqn60 n7 b vssx vssx nlp W=90n L=40n M=1
Mqn41 n8 n1 n7 vssx nlp W=90n L=40n M=1
Mqn30 n4 a vssx vssx nlp W=90n L=40n M=1
Mqn20 n2 a vssx vssx nlp W=90n L=40n M=1
Mqn10 n2 b vssx vssx nlp W=90n L=40n M=1
Mqn11 n1 c n2 vssx nlp W=90n L=40n M=1
Mqn72 n8 c n11 vssx nlp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfm201al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfm201al1n04x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n2 o vcc vssx ringpll__inv_pcell_36
Mqn2 n0 a vssx vssx nlp W=90n L=40n M=1
Mqn1 n2 a n0 vssx nlp W=90n L=40n M=1
Mqp2 n1 a vcc vcc plp W=90n L=40n M=1
Mqp1 n2 a n1 vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15clb0a2al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15clb0a2al1n04x5 clk clkout en vcc vssx m=1
* .PININFO clk:I en:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plp W=90n L=40n M=1
Mqp2 n0 en vcc vcc plp W=90n L=40n M=1
Mqn1 n0 clk n1 vssx nlp W=180n L=40n M=1
Mqn2 n1 en vssx vssx nlp W=180n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_36
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfn000al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn000al1n04x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_36
Mqn1 n1 a vssx vssx nlp W=90n L=40n M=1
Mqp1 n1 a vcc vcc plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15cbf000al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000al1n04x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plp W=90n L=40n M=1
Mqn1 n0 clk vssx vssx nlp W=135n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_36
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15ao0022al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15ao0022al1n04x5 a b c d o vcc vssx m=1
* .PININFO a:I b:I c:I d:I o:O vcc:B vssx:B
Mqn4 n3 d vssx vssx nlp W=90n L=40n M=1
Mqn2 n2 b vssx vssx nlp W=90n L=40n M=1
Mqn1 n4 a n2 vssx nlp W=90n L=40n M=1
Mqn3 n4 c n3 vssx nlp W=90n L=40n M=1
Mqp1 n4 a n1 vcc plp W=180n L=40n M=1
Mqp3 n1 c vcc vcc plp W=180n L=40n M=1
Mqp4 n1 d vcc vcc plp W=180n L=40n M=1
Mqp2 n4 b n1 vcc plp W=180n L=40n M=1
Xg101 n4 o vcc vssx ringpll__inv_pcell_36
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15and002al1n04x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002al1n04x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_35
Xg101 n1 o vcc vssx ringpll__inv_pcell_36
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch a enb o vcc_in vcc_out vssx
* .PININFO a:I enb:I vcc_in:I vcc_out:I vssx:I o:O
Mmn5 n5 a vssx vssx nlplvt W=180n L=40n M=2
Mmn0 n7 n6 vssx vssx nlplvt W=135n L=40n M=2
Mmn1 n7 n6 vssx vssx nlplvt W=180n L=40n M=2
Mmn4 n5 a vssx vssx nlplvt W=135n L=40n M=1
Xg1 enb n1 vcc_out vssx ringpll__inv_pcell_31
Xg2 n3 n4 vcc_out vssx ringpll__inv_pcell_32
Xg0 a n6 vcc_in vssx ringpll__inv_pcell_33
Xg3 n4 o vcc_out vssx ringpll__inv_pcell_34
Mqp12 n3 n2 vcc_out vcc_out ptgmv W=135n L=120n M=1
Mqp15 n2 n3 vcc_out vcc_out ptgmv W=90n L=120n M=1
Mmn3 n3 n1 n7 vssx ntgmv W=225n L=120n M=2
Mmn7 n2 n1 n5 vssx ntgmv W=180n L=120n M=2
Mmn8 n3 enb vssx vssx ntgmv W=135n L=120n M=1
MMN0[1] n3 enb vssx vssx ntgmv W=135n L=120n M=1
MMN0[0] n3 enb vssx vssx ntgmv W=135n L=120n M=1
Mqn11 n2 n3 vssx vssx ntgmv W=90.00n L=120n M=1
Mqn12 n3 n2 vssx vssx ntgmv W=90.00n L=120n M=1
Mmn11 n2 n1 n5 vssx ntgmv W=135n L=120n M=1
Mmn2 n3 n1 n7 vssx ntgmv W=180n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_tgate_logic_tg
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_tgate_logic_tg io1 io2 en vccxx vssx
* .PININFO en:I vccxx:I vssx:I io1:B io2:B
Xcinv0 en_b vccxx vssx en ringpll__xb15cinv00xu1n05x5
Xcinv1 en_d vccxx vssx en_b ringpll__xb15cinv00xu1n05x5
Mqn1[4] n0 en_d io1 vssx ntgmv W=180n L=120n M=1
Mqn1[3] n0 en_d io1 vssx ntgmv W=180n L=120n M=1
Mqn1[2] n0 en_d io1 vssx ntgmv W=180n L=120n M=1
Mqn1[1] n0 en_d io1 vssx ntgmv W=180n L=120n M=1
Mqn2[4] io2 en_d n0 vssx ntgmv W=180n L=120n M=1
Mqn2[3] io2 en_d n0 vssx ntgmv W=180n L=120n M=1
Mqn2[2] io2 en_d n0 vssx ntgmv W=180n L=120n M=1
Mqn2[1] io2 en_d n0 vssx ntgmv W=180n L=120n M=1
Mqp2[4] io2 en_b n1 n1 ptgmv W=180n L=120n M=1
Mqp2[3] io2 en_b n1 n1 ptgmv W=180n L=120n M=1
Mqp2[2] io2 en_b n1 n1 ptgmv W=180n L=120n M=1
Mqp2[1] io2 en_b n1 n1 ptgmv W=180n L=120n M=1
Mqp1[4] n1 en_b io1 n1 ptgmv W=180n L=120n M=1
Mqp1[3] n1 en_b io1 n1 ptgmv W=180n L=120n M=1
Mqp1[2] n1 en_b io1 n1 ptgmv W=180n L=120n M=1
Mqp1[1] n1 en_b io1 n1 ptgmv W=180n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15and002al1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15and002al1n12x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg1 a b n1 vcc vssx ringpll__na2_pcell_24
Xg101 n1 o vcc vssx ringpll__inv_pcell_6
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15fan07bxl1n08x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15fan07bxl1n08x5 o1 vccx vssx clk d enb rb s
* .PININFO clk:I d:I enb:I rb:I s:I o1:O vccx:B vssx:B
Xgtd1a nc2 nc1 nk4 nk3 vccx vssx ringpll__td_pcell_13
Xg101 nk5 o1 vccx vssx ringpll__inv_pcell_14
Xgclkn clk nc1 vccx vssx ringpll__inv_pcell_15
Xg99 nk5 nk6 vccx vssx ringpll__inv_pcell_16
Xg0 enb n7 vccx vssx ringpll__inv_pcell_16
Xg3 d nd vccx vssx ringpll__inv_pcell_17
Xg2 n10 n11 vccx vssx ringpll__inv_pcell_15
Xg1 nk6 n10 vccx vssx ringpll__inv_pcell_16
Xgclkdd nc1 nc2 vccx vssx ringpll__inv_pcell_16
Mqn11 n8 n7 nd vssx nlp W=135n L=40n M=1
Mqn12 n8 enb n11 vssx nlp W=135n L=40n M=1
Mqn13 nk3 nc1 n8 vssx nlp W=135.000n L=40n M=1
Xgd1k s nk6 rb nk12 vccx vssx ringpll__ba2no2_pcell_18
Xgd1 s nk3 rb nk4 vccx vssx ringpll__ba2no2_pcell_19
Mqp13 nk3 nc2 n9 vccx plp W=135.000n L=40n M=1
Mqp11 n9 enb nd vccx plp W=135n L=40n M=1
Mqp12 n9 n7 n11 vccx plp W=135n L=40n M=1
Xgtd2 nk4 nk5 clk nc1 vccx vssx ringpll__xf_pcell_20
Xgtd2a nk12 nk5 nc1 clk vccx vssx ringpll__xf_pcell_21
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    xb15bfm201xl1n02x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__xb15bfm201xl1n02x5 o vccx vssx a
* .PININFO a:I o:O vccx:B vssx:B
Mqn2 n0 a vssx vssx nlp W=90n L=40n M=1
Mqn1 n2 a n0 vssx nlp W=90n L=40n M=1
Xg101 n2 o vccx vssx ringpll__inv_pcell_16
Mqp2 n1 a vccx vccx plp W=90n L=40n M=1
Mqp1 n2 a n1 vccx plp W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_tgate_logic
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_tgate_logic io1 io2 en vccxx vssx
* .PININFO en:I vccxx:I vssx:I io1:B io2:B
Xcinv0 en_b vccxx vssx en ringpll__xb15cinv00xh1n05x5
Xcinv1 en_d vccxx vssx en_b ringpll__xb15cinv00xh1n05x5
Mqp1[4] n1 en_b io1 n1 p W=180n L=40n M=1
Mqp1[3] n1 en_b io1 n1 p W=180n L=40n M=1
Mqp1[2] n1 en_b io1 n1 p W=180n L=40n M=1
Mqp1[1] n1 en_b io1 n1 p W=180n L=40n M=1
Mqp2[4] io2 en_b n1 n1 p W=180n L=40n M=1
Mqp2[3] io2 en_b n1 n1 p W=180n L=40n M=1
Mqp2[2] io2 en_b n1 n1 p W=180n L=40n M=1
Mqp2[1] io2 en_b n1 n1 p W=180n L=40n M=1
Mqn1[4] n0 en_d io1 vssx n W=180n L=40n M=1
Mqn1[3] n0 en_d io1 vssx n W=180n L=40n M=1
Mqn1[2] n0 en_d io1 vssx n W=180n L=40n M=1
Mqn1[1] n0 en_d io1 vssx n W=180n L=40n M=1
Mqn2[4] io2 en_d n0 vssx n W=180n L=40n M=1
Mqn2[3] io2 en_d n0 vssx n W=180n L=40n M=1
Mqn2[2] io2 en_d n0 vssx n W=180n L=40n M=1
Mqn2[1] io2 en_d n0 vssx n W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15orn002al1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15orn002al1n12x5 a b o vcc vssx m=1
* .PININFO a:I b:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_6
Xg1 a b n1 vcc vssx ringpll__no2_pcell_7
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfn000al1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn000al1n12x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Xg101 n1 o vcc vssx ringpll__inv_pcell_6
Mqn1 n1 a vssx vssx nlp W=180n L=40n M=1
Mqp1 n1 a vcc vcc plp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15clb0a2al1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15clb0a2al1n12x5 clk clkout en vcc vssx m=1
* .PININFO clk:I en:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plp W=135n L=40n M=1
Mqp2 n0 en vcc vcc plp W=90n L=40n M=1
Mqn1 n0 clk n1 vssx nlp W=270n L=40n M=1
Mqn2 n1 en vssx vssx nlp W=270n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_6
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15cbf000al1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15cbf000al1n12x5 clk clkout vcc vssx m=1
* .PININFO clk:I clkout:O vcc:B vssx:B
Mqp1 n0 clk vcc vcc plp W=180n L=40n M=1
Mqn1 n0 clk vssx vssx nlp W=225n L=40n M=1
Xg201 n0 clkout vcc vssx ringpll__inv_pcell_6
.ENDS

* ***********************************************************************
*  Library Name: ln
*  Cell Name:    b15bfn001al1n12x5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__b15bfn001al1n12x5 a o vcc vssx m=1
* .PININFO a:I o:O vcc:B vssx:B
Mqn1 n1 a vssx vssx nlp W=270n L=40n M=1
Mqp1 n1 a vcc vcc plp W=270n L=40n M=1
Xg101 n1 o vcc vssx ringpll__inv_pcell_6
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22thmpassg4lu
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22thmpassg4lu io1 io2 vccxx vssx
* .PININFO vccxx:I vssx:I io1:B io2:B
Mqp2[2] io2 vssx n1 n1 p W=90n L=40n M=1
Mqp2[1] io2 vssx n1 n1 p W=90n L=40n M=1
Mqp2[0] io2 vssx n1 n1 p W=90n L=40n M=1
Mqp1[2] n1 vssx io1 n1 p W=90n L=40n M=1
Mqp1[1] n1 vssx io1 n1 p W=90n L=40n M=1
Mqp1[0] n1 vssx io1 n1 p W=90n L=40n M=1
Xinv0 enb vccxx vssx vssx ringpll__xb15inv000xn1n03x5
Mqn1[2] n0 enb io1 vssx n W=90n L=40n M=1
Mqn1[1] n0 enb io1 vssx n W=90n L=40n M=1
Mqn1[0] n0 enb io1 vssx n W=90n L=40n M=1
Mqn2[2] io2 enb n0 vssx n W=90n L=40n M=1
Mqn2[1] io2 enb n0 vssx n W=90n L=40n M=1
Mqn2[0] io2 enb n0 vssx n W=90n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22lpldo_2inmuxana
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22lpldo_2inmuxana sigout sela siga sigb vccxx vssx
* .PININFO sela:I siga:I sigb:I vccxx:I vssx:I sigout:O
Xipass1 siga sigout selad selb vccxx vssx ringpll__x22heldo_tgate
Xipass0 sigb sigout selb selad vccxx vssx ringpll__x22heldo_tgate
Xinv1 selb vccxx vssx sela ringpll__xb15inv000xn1n03x5
Xinv2 selad vccxx vssx selb ringpll__xb15inv000xn1n03x5
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_fbtgate
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_fbtgate tap0_out tap1_out tap2_out tap3_out tap4_out tap5_out tap6_out tap7_out tap8_out tap9_out tap10_out tap11_out tap12_out tap13_out tap14_out tap15_out enable tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 vccpll vssx
* .PININFO enable:I tap0:I tap1:I tap2:I tap3:I tap4:I tap5:I tap6:I tap7:I tap8:I tap9:I tap10:I tap11:I tap12:I tap13:I tap14:I tap15:I vccpll:I
* .PININFO vssx:I tap0_out:O tap1_out:O tap2_out:O tap3_out:O tap4_out:O tap5_out:O tap6_out:O tap7_out:O tap8_out:O tap9_out:O tap10_out:O
* .PININFO tap11_out:O tap12_out:O tap13_out:O tap14_out:O tap15_out:O
Xinv02 en_b vccpll vssx enable ringpll__xb15inv000xu1n05x5
Xinv03 en2 vccpll vssx en_b1 ringpll__xb15inv000xu1n20x5
Xinv01 en_b1 vccpll vssx en_1 ringpll__xb15inv000xu1n20x5
Xinv00 en_1 vccpll vssx en_b ringpll__xb15inv000xu1n06x5
Xipass9 tap9 tap9_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass13 tap13 tap13_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass12 tap12 tap12_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass15 tap15 tap15_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass14 tap14 tap14_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass8 tap8 tap8_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass11 tap11 tap11_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass10 tap10 tap10_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass5 tap5 tap5_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass4 tap4 tap4_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass7 tap7 tap7_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass6 tap6 tap6_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass0 tap0 tap0_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass3 tap3 tap3_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass2 tap2 tap2_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
Xipass1 tap1 tap1_out en2 en_b1 vccpll vssx ringpll__x22heldo_tgate_ll
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_enc4to16
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_enc4to16 dmfix_out[15] dmfix_out[14] dmfix_out[13] dmfix_out[12] dmfix_out[11] dmfix_out[10] dmfix_out[9] dmfix_out[8] dmfix_out[7] dmfix_out[6] dmfix_out[5] dmfix_out[4] dmfix_out[3] dmfix_out[2] dmfix_out[1] dmfix_out[0] outb[15] outb[14] outb[13] outb[12] outb[11] outb[10] outb[9] outb[8] outb[7] outb[6] outb[5] outb[4] outb[3] outb[2] outb[1] outb[0] dmfix_in[3] dmfix_in[2] dmfix_in[1] dmfix_in[0] vccxx vssx
* .PININFO dmfix_in[3]:I dmfix_in[2]:I dmfix_in[1]:I dmfix_in[0]:I vccxx:I vssx:I dmfix_out[15]:O dmfix_out[14]:O dmfix_out[13]:O dmfix_out[12]:O
* .PININFO dmfix_out[11]:O dmfix_out[10]:O dmfix_out[9]:O dmfix_out[8]:O dmfix_out[7]:O dmfix_out[6]:O dmfix_out[5]:O dmfix_out[4]:O dmfix_out[3]:O
* .PININFO dmfix_out[2]:O dmfix_out[1]:O dmfix_out[0]:O outb[15]:O outb[14]:O outb[13]:O outb[12]:O outb[11]:O outb[10]:O outb[9]:O outb[8]:O
* .PININFO outb[7]:O outb[6]:O outb[5]:O outb[4]:O outb[3]:O outb[2]:O outb[1]:O outb[0]:O
Xinv024 dmfix_out[2] vccxx vssx outb[2] ringpll__xb15inv000xn1n12x5
Xinv023 dmfix_out[3] vccxx vssx outb[3] ringpll__xb15inv000xn1n12x5
Xinv022 dmfix_out[4] vccxx vssx outb[4] ringpll__xb15inv000xn1n12x5
Xinv021 dmfix_out[5] vccxx vssx outb[5] ringpll__xb15inv000xn1n12x5
Xinv019 dmfix_out[7] vccxx vssx outb[7] ringpll__xb15inv000xn1n12x5
Xinv020 dmfix_out[6] vccxx vssx outb[6] ringpll__xb15inv000xn1n12x5
Xinv08 ind[1] vccxx vssx inb[1] ringpll__xb15inv000xn1n20x5
Xinv06 ind[3] vccxx vssx inb[3] ringpll__xb15inv000xn1n20x5
Xinv09 ind[0] vccxx vssx inb[0] ringpll__xb15inv000xn1n20x5
Xinv07 ind[2] vccxx vssx inb[2] ringpll__xb15inv000xn1n20x5
Xinv028 inb[0] vccxx vssx n113 ringpll__xb15inv000xn1n32x5
Xinv029 inb[1] vccxx vssx n75 ringpll__xb15inv000xn1n32x5
Xinv030 inb[2] vccxx vssx n74 ringpll__xb15inv000xn1n32x5
Xinv031 inb[3] vccxx vssx n73 ringpll__xb15inv000xn1n32x5
Xnand7 outb[8] vccxx vssx ind[3] inb[2] inb[1] inb[0] ringpll__xb15nand24xn1n08x5
Xnand1 outb[14] vccxx vssx ind[3] ind[2] ind[1] inb[0] ringpll__xb15nand24xn1n08x5
Xnand3 outb[12] vccxx vssx ind[3] ind[2] inb[1] inb[0] ringpll__xb15nand24xn1n08x5
Xnand5 outb[10] vccxx vssx ind[3] inb[2] ind[1] inb[0] ringpll__xb15nand24xn1n08x5
Xnand11 outb[4] vccxx vssx inb[3] ind[2] inb[1] inb[0] ringpll__xb15nand24xn1n08x5
Xnand10 outb[5] vccxx vssx inb[3] ind[2] inb[1] ind[0] ringpll__xb15nand24xn1n08x5
Xnand9 outb[6] vccxx vssx inb[3] ind[2] ind[1] inb[0] ringpll__xb15nand24xn1n08x5
Xnand8 outb[7] vccxx vssx inb[3] ind[2] ind[1] ind[0] ringpll__xb15nand24xn1n08x5
Xnand6 outb[9] vccxx vssx ind[3] inb[2] inb[1] ind[0] ringpll__xb15nand24xn1n08x5
Xnand4 outb[11] vccxx vssx ind[3] inb[2] ind[1] ind[0] ringpll__xb15nand24xn1n08x5
Xnand2 outb[13] vccxx vssx ind[3] ind[2] inb[1] ind[0] ringpll__xb15nand24xn1n08x5
Xnand0 outb[15] vccxx vssx ind[3] ind[2] ind[1] ind[0] ringpll__xb15nand24xn1n08x5
Xnand12 outb[3] vccxx vssx inb[3] inb[2] ind[1] ind[0] ringpll__xb15nand24xn1n08x5
Xnand13 outb[2] vccxx vssx inb[3] inb[2] ind[1] inb[0] ringpll__xb15nand24xn1n08x5
Xnand14 outb[1] vccxx vssx inb[3] inb[2] inb[1] ind[0] ringpll__xb15nand24xn1n08x5
Xnand15 outb[0] vccxx vssx inb[3] inb[2] inb[1] inb[0] ringpll__xb15nand24xn1n08x5
Xinv027 n73 vccxx vssx n114 ringpll__xb15inv000xn1n06x5
Xinv010 n74 vccxx vssx n115 ringpll__xb15inv000xn1n06x5
Xinv05 n75 vccxx vssx n116 ringpll__xb15inv000xn1n06x5
Xinv04 n113 vccxx vssx n117 ringpll__xb15inv000xn1n06x5
Xinv017 dmfix_out[9] vccxx vssx outb[9] ringpll__xb15inv000xn1n06x5
Xinv00 n117 vccxx vssx dmfix_in[0] ringpll__xb15inv000xn1n05x5
Xinv026 dmfix_out[0] vccxx vssx outb[0] ringpll__xb15inv000xn1n05x5
Xinv011 dmfix_out[15] vccxx vssx outb[15] ringpll__xb15inv000xn1n05x5
Xinv016 dmfix_out[10] vccxx vssx outb[10] ringpll__xb15inv000xn1n05x5
Xinv03 n115 vccxx vssx dmfix_in[2] ringpll__xb15inv000xn1n05x5
Xinv01 n116 vccxx vssx dmfix_in[1] ringpll__xb15inv000xn1n05x5
Xinv02 n114 vccxx vssx dmfix_in[3] ringpll__xb15inv000xn1n05x5
Xinv025 dmfix_out[1] vccxx vssx outb[1] ringpll__xb15inv000xn1n05x5
Xinv015 dmfix_out[11] vccxx vssx outb[11] ringpll__xb15inv000xn1n05x5
Xinv013 dmfix_out[13] vccxx vssx outb[13] ringpll__xb15inv000xn1n05x5
Xinv012 dmfix_out[14] vccxx vssx outb[14] ringpll__xb15inv000xn1n05x5
Xinv018 dmfix_out[8] vccxx vssx outb[8] ringpll__xb15inv000xn1n05x5
Xinv014 dmfix_out[12] vccxx vssx outb[12] ringpll__xb15inv000xn1n05x5
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddjpu6ogdxnxcnx
* ***********************************************************************
.SUBCKT b88xesddjpu6ogdxnxcnx pad_uhv vcc_uhv
* .PININFO pad_uhv:B vcc_uhv:B
Xdjpm1 pad_uhv vcc_uhv b88xesddjpu1ogdxnxunx
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddjnu6ogdxnxcnx
* ***********************************************************************
.SUBCKT b88xesddjnu6ogdxnxcnx pad_uhv vssx
* .PININFO pad_uhv:B vssx:B
Xdjnm1 pad_uhv vssx b88xesddjnu1ogdxnxunx
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_dnw_pcell_5
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_dnw_pcell_5 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_tfr_dnw multX=1 multY=1 w=180n l=705.00n rlegs=1 wcon=0 ncon=0 dummy=0 config=0 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_dnw_pcell_10
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_dnw_pcell_10 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_tfr_dnw multX=1 multY=1 w=180n l=2.01u rlegs=2 wcon=44n ncon=1 dummy=0 config=3 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_dnw_pcell_9
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_dnw_pcell_9 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_tfr_dnw multX=1 multY=1 w=180n l=2.01u rlegs=2 wcon=44n ncon=1 dummy=0 config=3 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_dnw_pcell_0
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_dnw_pcell_0 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_tfr_dnw multX=1 multY=1 w=180n l=705.00n rlegs=1 wcon=0 ncon=0 dummy=0 config=0 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_dnw_pcell_1
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_dnw_pcell_1 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_tfr_dnw multX=1 multY=1 w=180n l=705.00n rlegs=1 wcon=0 ncon=0 dummy=0 config=0 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_dnw_pcell_2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_dnw_pcell_2 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_tfr_dnw multX=1 multY=1 w=180n l=705n rlegs=1 wcon=0 ncon=0 dummy=0 config=0 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_dnw_pcell_3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_dnw_pcell_3 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_tfr_dnw multX=1 multY=1 w=180n l=705n rlegs=1 wcon=0 ncon=0 dummy=0 config=0 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_dnw_pcell_4
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_dnw_pcell_4 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_tfr_dnw multX=1 multY=1 w=180n l=705.00n rlegs=1 wcon=0 ncon=0 dummy=0 config=0 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_pcell_105
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_pcell_105 a b nwl
* .PININFO a:B b:B nwl:B
Xi0 a b nwl b88xp_tfr multX=1 multY=1 w=576.00n l=2.865u rlegs=2 wcon=108n ncon=3 dummy=0 config=1 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_pcell_28
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_pcell_28 a b nwl
* .PININFO a:B b:B nwl:B
Xi0 a b nwl b88xp_tfr multX=1 multY=1 w=180n l=3.81u rlegs=1 wcon=0 ncon=0 dummy=0 config=0 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_pcell_133
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_pcell_133 a b nwl
* .PININFO a:B b:B nwl:B
Xi0 a b nwl b88xp_tfr multX=1 multY=1 w=576.00n l=19.2u rlegs=2 wcon=108n ncon=3 dummy=0 config=1 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_pcell_78
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_pcell_78 a b nwl
* .PININFO a:B b:B nwl:B
Xi0 a b nwl b88xp_tfr multX=1 multY=1 w=180n l=2.1u rlegs=4 wcon=44n ncon=1 dummy=0 config=3 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_pcell_136
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_pcell_136 a b nwl
* .PININFO a:B b:B nwl:B
Xi0 a b nwl b88xp_tfr multX=1 multY=1 w=576.00n l=5.745u rlegs=2 wcon=108n ncon=3 dummy=0 config=1 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_pcell_137
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_pcell_137 a b nwl
* .PININFO a:B b:B nwl:B
Xi0 a b nwl b88xp_tfr multX=1 multY=1 w=576.00n l=11.46u rlegs=2 wcon=108n ncon=3 dummy=0 config=1 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_pcell_100
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_pcell_100 a b nwl
* .PININFO a:B b:B nwl:B
Xi0 a b nwl b88xp_tfr multX=1 multY=1 w=576.00n l=8.715u rlegs=1 wcon=108n ncon=3 dummy=0 config=1 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_pcell_102
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_pcell_102 a b nwl
* .PININFO a:B b:B nwl:B
Xi0 a b nwl b88xp_tfr multX=1 multY=1 w=540n l=5.52u rlegs=4 wcon=44n ncon=1 dummy=0 config=1 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    res_tfr_pcell_103
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__res_tfr_pcell_103 a b nwl
* .PININFO a:B b:B nwl:B
Xi0 a b nwl b88xp_tfr multX=1 multY=1 w=576n l=525n rlegs=4 wcon=108n ncon=2 dummy=0 config=1 tnoise=1 fnoise=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2g_pcell_11
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2g_pcell_11 a b
* .PININFO a:B b:B
Xi0 a b b88xp_mfcs2g mtop=3 mbot=1 w=60.04u l=24.94u multx=1 multy=1 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2g_pcell_12
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2g_pcell_12 a b
* .PININFO a:B b:B
Xi0 a b b88xp_mfcs2g mtop=5 mbot=1 w=34.12u l=20.08u multx=1 multy=1 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2g_pcell_29
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2g_pcell_29 a b
* .PININFO a:B b:B
Xi0 a b b88xp_mfcs2g mtop=3 mbot=1 w=4.96u l=4.96u multx=1 multy=1 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2g_pcell_128
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2g_pcell_128 a b
* .PININFO a:B b:B
Xi0 a b b88xp_mfcs2g mtop=5 mbot=1 w=10.36u l=8.74u multx=4 multy=1 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2p_pcell_129
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2p_pcell_129 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_mfcs2p mtop=5 mbot=1 w=10.36u l=8.74u multx=4 multy=1 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2p_pcell_134
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2p_pcell_134 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_mfcs2p mtop=5 mbot=1 w=15.76u l=8.74u multx=3 multy=2 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2p_pcell_135
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2p_pcell_135 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_mfcs2p mtop=5 mbot=1 w=15.76u l=8.74u multx=1 multy=2 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2p_pcell_138
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2p_pcell_138 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_mfcs2p mtop=5 mbot=1 w=16.84u l=6.58u multx=6 multy=18 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2p_pcell_139
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2p_pcell_139 a b vssx
* .PININFO a:B b:B vssx:B
Xi0 a b vssx b88xp_mfcs2p mtop=5 mbot=1 w=16.3u l=6.58u multx=6 multy=18 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2s_ls_pcell_120
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2s_ls_pcell_120 a b lowershield vssx
* .PININFO a:B b:B lowershield:B vssx:B
Xi0 a b lowershield vssx b88xp_mfcs2sls mtop=6 mbot=1 w=12.52u l=14.14u multx=1 multy=1 fill=1 via=1 shield=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2s_ls_pcell_121
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2s_ls_pcell_121 a b lowershield vssx
* .PININFO a:B b:B lowershield:B vssx:B
Xi0 a b lowershield vssx b88xp_mfcs2sls mtop=6 mbot=1 w=6.04u l=10.9u multx=1 multy=1 fill=1 via=1 shield=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2s_ls_pcell_125
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2s_ls_pcell_125 a b lowershield vssx
* .PININFO a:B b:B lowershield:B vssx:B
Xi0 a b lowershield vssx b88xp_mfcs2sls mtop=6 mbot=1 w=4.96u l=4.96u multx=1 multy=1 fill=1 via=1 shield=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2s_ls_pcell_126
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2s_ls_pcell_126 a b lowershield vssx
* .PININFO a:B b:B lowershield:B vssx:B
Xi0 a b lowershield vssx b88xp_mfcs2sls mtop=6 mbot=1 w=15.76u l=7.12u multx=1 multy=1 fill=1 via=1 shield=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2s_ls_pcell_127
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2s_ls_pcell_127 a b lowershield vssx
* .PININFO a:B b:B lowershield:B vssx:B
Xi0 a b lowershield vssx b88xp_mfcs2sls mtop=6 mbot=1 w=15.76u l=4.42u multx=1 multy=1 fill=1 via=1 shield=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2s_pcell_8
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2s_pcell_8 a b lowershield uppershield vssx
* .PININFO a:B b:B lowershield:B uppershield:B vssx:B
Xi0 a b lowershield uppershield vssx b88xp_mfcs2s mtop=4 mbot=1 w=12.52u l=12.52u multx=1 multy=1 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2s_pcell_26
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2s_pcell_26 a b lowershield uppershield vssx
* .PININFO a:B b:B lowershield:B uppershield:B vssx:B
Xi0 a b lowershield uppershield vssx b88xp_mfcs2s mtop=5 mbot=1 w=25.48u l=23.86u multx=1 multy=1 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2s_pcell_93
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2s_pcell_93 a b lowershield uppershield vssx
* .PININFO a:B b:B lowershield:B uppershield:B vssx:B
Xi0 a b lowershield uppershield vssx b88xp_mfcs2s mtop=4 mbot=1 w=3.88u l=3.88u multx=2 multy=2 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    mfc_s2s_pcell_94
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mfc_s2s_pcell_94 a b lowershield uppershield vssx
* .PININFO a:B b:B lowershield:B uppershield:B vssx:B
Xi0 a b lowershield uppershield vssx b88xp_mfcs2s mtop=4 mbot=1 w=3.88u l=3.88u multx=1 multy=1 fill=1 via=1 shield=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_27
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_27 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=6 mbot=1 w=1.72u l=1.36u multx=14 multy=34 fill=1 via=1 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_179
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_179 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=6 mbot=1 w=1.72u l=1.36u multx=1.387K multy=2 fill=1 via=1 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_40
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_40 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=6 mbot=1 w=1.72u l=1.36u multx=124 multy=17 fill=1 via=1 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_79
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_79 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=2 mbot=1 w=1.72u l=1.36u multx=8 multy=8 fill=1 via=0 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_54
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_54 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=6 mbot=1 w=1.72u l=1.36u multx=19 multy=41 fill=1 via=1 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_30
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_30 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=5 mbot=1 w=1.72u l=1.36u multx=7 multy=3 fill=1 via=1 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_180
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_180 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=6 mbot=1 w=1.72u l=1.36u multx=1 multy=2 fill=1 via=1 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_181
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_181 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=6 mbot=1 w=1.72u l=1.36u multx=18 multy=18 fill=1 via=1 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_22
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_22 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=5 mbot=1 w=1.72u l=1.36u multx=6 multy=4 fill=1 via=1 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_23
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_23 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=3 mbot=1 w=1.72u l=1.36u multx=3 multy=4 fill=1 via=1 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name:    pdecap_s2p_pcell_25
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pdecap_s2p_pcell_25 a b
* .PININFO a:B b:B
Xi0 a b b88xp_dcps2p mtop=5 mbot=1 w=1.72u l=1.36u multx=7 multy=6 fill=1 via=1 shield=0 vmax=1 ttype=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_inbuf_ln
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_inbuf_ln o a vccx vssx
* .PININFO a:I vccx:I vssx:I o:O
Xydpd0 a vccx vssx ringpll__b15ydp151an1n03x5 m=1
Xbfn00 a o vccx vssx ringpll__b15bfn001al1n12x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    tcu_tpsb_stap_data_reg_269_0_1
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__tcu_tpsb_stap_data_reg_269_0_1 dm_sync_reset ftap_tck ftap_tdi reset_b stap_irdecoder_drselect stap_fsm_capture_dr stap_fsm_shift_dr stap_fsm_update_dr tdr_data_in[268] tdr_data_in[267] tdr_data_in[266] tdr_data_in[265] tdr_data_in[264] tdr_data_in[263] tdr_data_in[262] tdr_data_in[261] tdr_data_in[260] tdr_data_in[259] tdr_data_in[258] tdr_data_in[257] tdr_data_in[256] tdr_data_in[255] tdr_data_in[254] tdr_data_in[253] tdr_data_in[252] tdr_data_in[251] tdr_data_in[250] tdr_data_in[249] tdr_data_in[248] tdr_data_in[247] tdr_data_in[246] tdr_data_in[245] tdr_data_in[244] tdr_data_in[243] tdr_data_in[242] tdr_data_in[241] tdr_data_in[240] tdr_data_in[239] tdr_data_in[238] tdr_data_in[237] tdr_data_in[236] tdr_data_in[235] tdr_data_in[234] tdr_data_in[233] tdr_data_in[232] tdr_data_in[231] tdr_data_in[230] tdr_data_in[229] tdr_data_in[228] tdr_data_in[227] tdr_data_in[226] tdr_data_in[225] tdr_data_in[224] tdr_data_in[223] tdr_data_in[222] tdr_data_in[221] tdr_data_in[220] tdr_data_in[219] tdr_data_in[218] tdr_data_in[217] tdr_data_in[216] tdr_data_in[215] tdr_data_in[214] tdr_data_in[213] tdr_data_in[212] tdr_data_in[211] tdr_data_in[210] tdr_data_in[209] tdr_data_in[208] tdr_data_in[207] tdr_data_in[206] tdr_data_in[205] tdr_data_in[204] tdr_data_in[203] tdr_data_in[202] tdr_data_in[201] tdr_data_in[200] tdr_data_in[199] tdr_data_in[198] tdr_data_in[197] tdr_data_in[196] tdr_data_in[195] tdr_data_in[194] tdr_data_in[193] tdr_data_in[192] tdr_data_in[191] tdr_data_in[190] tdr_data_in[189] tdr_data_in[188] tdr_data_in[187] tdr_data_in[186] tdr_data_in[185] tdr_data_in[184] tdr_data_in[183] tdr_data_in[182] tdr_data_in[181] tdr_data_in[180] tdr_data_in[179] tdr_data_in[178] tdr_data_in[177] tdr_data_in[176] tdr_data_in[175] tdr_data_in[174] tdr_data_in[173] tdr_data_in[172] tdr_data_in[171] tdr_data_in[170] tdr_data_in[169] tdr_data_in[168] tdr_data_in[167] tdr_data_in[166] tdr_data_in[165] tdr_data_in[164] tdr_data_in[163] tdr_data_in[162] tdr_data_in[161] tdr_data_in[160] tdr_data_in[159] tdr_data_in[158] tdr_data_in[157] tdr_data_in[156] tdr_data_in[155] tdr_data_in[154] tdr_data_in[153] tdr_data_in[152] tdr_data_in[151] tdr_data_in[150] tdr_data_in[149] tdr_data_in[148] tdr_data_in[147] tdr_data_in[146] tdr_data_in[145] tdr_data_in[144] tdr_data_in[143] tdr_data_in[142] tdr_data_in[141] tdr_data_in[140] tdr_data_in[139] tdr_data_in[138] tdr_data_in[137] tdr_data_in[136] tdr_data_in[135] tdr_data_in[134] tdr_data_in[133] tdr_data_in[132] tdr_data_in[131] tdr_data_in[130] tdr_data_in[129] tdr_data_in[128] tdr_data_in[127] tdr_data_in[126] tdr_data_in[125] tdr_data_in[124] tdr_data_in[123] tdr_data_in[122] tdr_data_in[121] tdr_data_in[120] tdr_data_in[119] tdr_data_in[118] tdr_data_in[117] tdr_data_in[116] tdr_data_in[115] tdr_data_in[114] tdr_data_in[113] tdr_data_in[112] tdr_data_in[111] tdr_data_in[110] tdr_data_in[109] tdr_data_in[108] tdr_data_in[107] tdr_data_in[106] tdr_data_in[105] tdr_data_in[104] tdr_data_in[103] tdr_data_in[102] tdr_data_in[101] tdr_data_in[100] tdr_data_in[99] tdr_data_in[98] tdr_data_in[97] tdr_data_in[96] tdr_data_in[95] tdr_data_in[94] tdr_data_in[93] tdr_data_in[92] tdr_data_in[91] tdr_data_in[90] tdr_data_in[89] tdr_data_in[88] tdr_data_in[87] tdr_data_in[86] tdr_data_in[85] tdr_data_in[84] tdr_data_in[83] tdr_data_in[82] tdr_data_in[81] tdr_data_in[80] tdr_data_in[79] tdr_data_in[78] tdr_data_in[77] tdr_data_in[76] tdr_data_in[75] tdr_data_in[74] tdr_data_in[73] tdr_data_in[72] tdr_data_in[71] tdr_data_in[70] tdr_data_in[69] tdr_data_in[68] tdr_data_in[67] tdr_data_in[66] tdr_data_in[65] tdr_data_in[64] tdr_data_in[63] tdr_data_in[62] tdr_data_in[61] tdr_data_in[60] tdr_data_in[59] tdr_data_in[58] tdr_data_in[57] tdr_data_in[56] tdr_data_in[55] tdr_data_in[54] tdr_data_in[53] tdr_data_in[52] tdr_data_in[51] tdr_data_in[50] tdr_data_in[49] tdr_data_in[48] tdr_data_in[47] tdr_data_in[46] tdr_data_in[45] tdr_data_in[44] tdr_data_in[43] tdr_data_in[42] tdr_data_in[41] tdr_data_in[40] tdr_data_in[39] tdr_data_in[38] tdr_data_in[37] tdr_data_in[36] tdr_data_in[35] tdr_data_in[34] tdr_data_in[33] tdr_data_in[32] tdr_data_in[31] tdr_data_in[30] tdr_data_in[29] tdr_data_in[28] tdr_data_in[27] tdr_data_in[26] tdr_data_in[25] tdr_data_in[24] tdr_data_in[23] tdr_data_in[22] tdr_data_in[21] tdr_data_in[20] tdr_data_in[19] tdr_data_in[18] tdr_data_in[17] tdr_data_in[16] tdr_data_in[15] tdr_data_in[14] tdr_data_in[13] tdr_data_in[12] tdr_data_in[11] tdr_data_in[10] tdr_data_in[9] tdr_data_in[8] tdr_data_in[7] tdr_data_in[6] tdr_data_in[5] tdr_data_in[4] tdr_data_in[3] tdr_data_in[2] tdr_data_in[1] tdr_data_in[0] data_reg_tdo tdr_data_out[268] tdr_data_out[267] tdr_data_out[266] tdr_data_out[265] tdr_data_out[264] tdr_data_out[263] tdr_data_out[262] tdr_data_out[261] tdr_data_out[260] tdr_data_out[259] tdr_data_out[258] tdr_data_out[257] tdr_data_out[256] tdr_data_out[255] tdr_data_out[254] tdr_data_out[253] tdr_data_out[252] tdr_data_out[251] tdr_data_out[250] tdr_data_out[249] tdr_data_out[248] tdr_data_out[247] tdr_data_out[246] tdr_data_out[245] tdr_data_out[244] tdr_data_out[243] tdr_data_out[242] tdr_data_out[241] tdr_data_out[240] tdr_data_out[239] tdr_data_out[238] tdr_data_out[237] tdr_data_out[236] tdr_data_out[235] tdr_data_out[234] tdr_data_out[233] tdr_data_out[232] tdr_data_out[231] tdr_data_out[230] tdr_data_out[229] tdr_data_out[228] tdr_data_out[227] tdr_data_out[226] tdr_data_out[225] tdr_data_out[224] tdr_data_out[223] tdr_data_out[222] tdr_data_out[221] tdr_data_out[220] tdr_data_out[219] tdr_data_out[218] tdr_data_out[217] tdr_data_out[216] tdr_data_out[215] tdr_data_out[214] tdr_data_out[213] tdr_data_out[212] tdr_data_out[211] tdr_data_out[210] tdr_data_out[209] tdr_data_out[208] tdr_data_out[207] tdr_data_out[206] tdr_data_out[205] tdr_data_out[204] tdr_data_out[203] tdr_data_out[202] tdr_data_out[201] tdr_data_out[200] tdr_data_out[199] tdr_data_out[198] tdr_data_out[197] tdr_data_out[196] tdr_data_out[195] tdr_data_out[194] tdr_data_out[193] tdr_data_out[192] tdr_data_out[191] tdr_data_out[190] tdr_data_out[189] tdr_data_out[188] tdr_data_out[187] tdr_data_out[186] tdr_data_out[185] tdr_data_out[184] tdr_data_out[183] tdr_data_out[182] tdr_data_out[181] tdr_data_out[180] tdr_data_out[179] tdr_data_out[178] tdr_data_out[177] tdr_data_out[176] tdr_data_out[175] tdr_data_out[174] tdr_data_out[173] tdr_data_out[172] tdr_data_out[171] tdr_data_out[170] tdr_data_out[169] tdr_data_out[168] tdr_data_out[167] tdr_data_out[166] tdr_data_out[165] tdr_data_out[164] tdr_data_out[163] tdr_data_out[162] tdr_data_out[161] tdr_data_out[160] tdr_data_out[159] tdr_data_out[158] tdr_data_out[157] tdr_data_out[156] tdr_data_out[155] tdr_data_out[154] tdr_data_out[153] tdr_data_out[152] tdr_data_out[151] tdr_data_out[150] tdr_data_out[149] tdr_data_out[148] tdr_data_out[147] tdr_data_out[146] tdr_data_out[145] tdr_data_out[144] tdr_data_out[143] tdr_data_out[142] tdr_data_out[141] tdr_data_out[140] tdr_data_out[139] tdr_data_out[138] tdr_data_out[137] tdr_data_out[136] tdr_data_out[135] tdr_data_out[134] tdr_data_out[133] tdr_data_out[132] tdr_data_out[131] tdr_data_out[130] tdr_data_out[129] tdr_data_out[128] tdr_data_out[127] tdr_data_out[126] tdr_data_out[125] tdr_data_out[124] tdr_data_out[123] tdr_data_out[122] tdr_data_out[121] tdr_data_out[120] tdr_data_out[119] tdr_data_out[118] tdr_data_out[117] tdr_data_out[116] tdr_data_out[115] tdr_data_out[114] tdr_data_out[113] tdr_data_out[112] tdr_data_out[111] tdr_data_out[110] tdr_data_out[109] tdr_data_out[108] tdr_data_out[107] tdr_data_out[106] tdr_data_out[105] tdr_data_out[104] tdr_data_out[103] tdr_data_out[102] tdr_data_out[101] tdr_data_out[100] tdr_data_out[99] tdr_data_out[98] tdr_data_out[97] tdr_data_out[96] tdr_data_out[95] tdr_data_out[94] tdr_data_out[93] tdr_data_out[92] tdr_data_out[91] tdr_data_out[90] tdr_data_out[89] tdr_data_out[88] tdr_data_out[87] tdr_data_out[86] tdr_data_out[85] tdr_data_out[84] tdr_data_out[83] tdr_data_out[82] tdr_data_out[81] tdr_data_out[80] tdr_data_out[79] tdr_data_out[78] tdr_data_out[77] tdr_data_out[76] tdr_data_out[75] tdr_data_out[74] tdr_data_out[73] tdr_data_out[72] tdr_data_out[71] tdr_data_out[70] tdr_data_out[69] tdr_data_out[68] tdr_data_out[67] tdr_data_out[66] tdr_data_out[65] tdr_data_out[64] tdr_data_out[63] tdr_data_out[62] tdr_data_out[61] tdr_data_out[60] tdr_data_out[59] tdr_data_out[58] tdr_data_out[57] tdr_data_out[56] tdr_data_out[55] tdr_data_out[54] tdr_data_out[53] tdr_data_out[52] tdr_data_out[51] tdr_data_out[50] tdr_data_out[49] tdr_data_out[48] tdr_data_out[47] tdr_data_out[46] tdr_data_out[45] tdr_data_out[44] tdr_data_out[43] tdr_data_out[42] tdr_data_out[41] tdr_data_out[40] tdr_data_out[39] tdr_data_out[38] tdr_data_out[37] tdr_data_out[36] tdr_data_out[35] tdr_data_out[34] tdr_data_out[33] tdr_data_out[32] tdr_data_out[31] tdr_data_out[30] tdr_data_out[29] tdr_data_out[28] tdr_data_out[27] tdr_data_out[26] tdr_data_out[25] tdr_data_out[24] tdr_data_out[23] tdr_data_out[22] tdr_data_out[21] tdr_data_out[20] tdr_data_out[19] tdr_data_out[18] tdr_data_out[17] tdr_data_out[16] tdr_data_out[15] tdr_data_out[14] tdr_data_out[13] tdr_data_out[12] tdr_data_out[11] tdr_data_out[10] tdr_data_out[9] tdr_data_out[8] tdr_data_out[7] tdr_data_out[6] tdr_data_out[5] tdr_data_out[4] tdr_data_out[3] tdr_data_out[2] tdr_data_out[1] tdr_data_out[0] vdd vssx p0 p3 p_abuf0 p_abuf1 p_abuf2 p_abuf3 p_abuf4 p_abuf5 p_abuf6 p4 p1 p2 p5 p6 p7 p8 p_abuf14 p_abuf15 p_abuf16 p_abuf17 p_abuf18 p_abuf19 p_abuf20 p_abuf21 p_abuf22 p_abuf23 p_abuf24 p_abuf25 p_abuf26 p_abuf27 p_abuf28 p_abuf29 p_abuf30 p_abuf31 p_abuf32 p_abuf33 p_abuf34 p_abuf35 p_abuf36 p_abuf37 p_abuf38 p_abuf39 p_abuf40 p_abuf41 p_abuf42 p_abuf43 p_abuf44 p_abuf45 p_abuf46 p_abuf47 p_abuf48 p_abuf49 p_abuf50 p_abuf51 p_abuf52 p_abuf53 p_abuf54 p_abuf55 p_abuf56 p_abuf57 p_abuf58 p_abuf59 p_abuf60 p_abuf61 p_abuf62 p_abuf63 p_abuf64 p_abuf65 p_abuf66 p_abuf67 p_abuf68 p_abuf69 p9 p10 p12 p13 p14 p15 p16 p17 p18 p19 p20 p21 p22 p23 p24 p25 p26 p27 p28 p29 p30 p31 p32 p33 p34 p35 p36 p37 p38 p39 p40 p41 p42 p43 p44 p45 p46 p47 p48 p49 p50 p51 p52 p53 p54 p55 p56 p57 p58 p59 p60 p_abuf7 p_abuf8 p_abuf9 p_abuf10 p_abuf11 p_abuf12 p_abuf13 p_abuf70 p_abuf71 p_abuf72 p_abuf73 p_abuf74 p_abuf75 p_abuf76 p_abuf77 p_abuf78 p_abuf79 p_abuf80 p_abuf81 p_abuf82 p_abuf83 p_abuf84 p_abuf85 p_abuf86 p_abuf87 p_abuf88 p_abuf89 p_abuf90 p_abuf91 p_abuf92 p_abuf93 p_abuf94 p_abuf95 p_abuf96 p_abuf97 p_abuf98 p_abuf99 p_abuf100 p_abuf101 p_abuf102 p_abuf103 p61
* .PININFO dm_sync_reset:I ftap_tck:I ftap_tdi:I p0:I p1:I p2:I p3:I p4:I p5:I p6:I p7:I p8:I p9:I p10:I p12:I p13:I p14:I p15:I p16:I p17:I p18:I
* .PININFO p19:I p20:I p21:I p22:I p23:I p24:I p25:I p26:I p27:I p28:I p29:I p30:I p31:I p32:I p33:I p34:I p35:I p36:I p37:I p38:I p39:I p40:I p41:I
* .PININFO p42:I p43:I p44:I p45:I p46:I p47:I p48:I p49:I p50:I p51:I p52:I p53:I p54:I p55:I p56:I p57:I p58:I p59:I p60:I p61:I p_abuf16:I
* .PININFO p_abuf17:I p_abuf18:I p_abuf19:I p_abuf20:I p_abuf21:I p_abuf22:I p_abuf23:I p_abuf24:I p_abuf25:I p_abuf26:I p_abuf27:I p_abuf28:I
* .PININFO p_abuf29:I p_abuf30:I p_abuf31:I p_abuf32:I p_abuf33:I p_abuf34:I p_abuf35:I p_abuf36:I p_abuf37:I p_abuf38:I p_abuf39:I p_abuf40:I
* .PININFO p_abuf41:I p_abuf42:I p_abuf43:I p_abuf44:I p_abuf45:I p_abuf46:I p_abuf47:I p_abuf48:I p_abuf49:I p_abuf50:I p_abuf51:I p_abuf52:I
* .PININFO p_abuf53:I p_abuf54:I p_abuf55:I p_abuf56:I p_abuf57:I p_abuf58:I p_abuf59:I p_abuf60:I p_abuf61:I p_abuf62:I p_abuf63:I p_abuf64:I
* .PININFO p_abuf65:I p_abuf66:I p_abuf67:I p_abuf68:I p_abuf69:I p_abuf72:I p_abuf73:I p_abuf74:I p_abuf75:I p_abuf76:I p_abuf77:I p_abuf78:I
* .PININFO p_abuf79:I p_abuf80:I p_abuf81:I p_abuf82:I p_abuf83:I p_abuf84:I p_abuf85:I p_abuf86:I p_abuf87:I p_abuf88:I p_abuf89:I p_abuf90:I
* .PININFO p_abuf91:I p_abuf92:I p_abuf93:I p_abuf94:I p_abuf95:I p_abuf96:I p_abuf97:I p_abuf98:I p_abuf99:I p_abuf100:I p_abuf101:I p_abuf102:I
* .PININFO p_abuf103:I reset_b:I stap_fsm_capture_dr:I stap_fsm_shift_dr:I stap_fsm_update_dr:I stap_irdecoder_drselect:I tdr_data_in[268]:I
* .PININFO tdr_data_in[267]:I tdr_data_in[266]:I tdr_data_in[265]:I tdr_data_in[264]:I tdr_data_in[263]:I tdr_data_in[262]:I tdr_data_in[261]:I
* .PININFO tdr_data_in[260]:I tdr_data_in[259]:I tdr_data_in[258]:I tdr_data_in[257]:I tdr_data_in[256]:I tdr_data_in[255]:I tdr_data_in[254]:I
* .PININFO tdr_data_in[253]:I tdr_data_in[252]:I tdr_data_in[251]:I tdr_data_in[250]:I tdr_data_in[249]:I tdr_data_in[248]:I tdr_data_in[247]:I
* .PININFO tdr_data_in[246]:I tdr_data_in[245]:I tdr_data_in[244]:I tdr_data_in[243]:I tdr_data_in[242]:I tdr_data_in[241]:I tdr_data_in[240]:I
* .PININFO tdr_data_in[239]:I tdr_data_in[238]:I tdr_data_in[237]:I tdr_data_in[236]:I tdr_data_in[235]:I tdr_data_in[234]:I tdr_data_in[233]:I
* .PININFO tdr_data_in[232]:I tdr_data_in[231]:I tdr_data_in[230]:I tdr_data_in[229]:I tdr_data_in[228]:I tdr_data_in[227]:I tdr_data_in[226]:I
* .PININFO tdr_data_in[225]:I tdr_data_in[224]:I tdr_data_in[223]:I tdr_data_in[222]:I tdr_data_in[221]:I tdr_data_in[220]:I tdr_data_in[219]:I
* .PININFO tdr_data_in[218]:I tdr_data_in[217]:I tdr_data_in[216]:I tdr_data_in[215]:I tdr_data_in[214]:I tdr_data_in[213]:I tdr_data_in[212]:I
* .PININFO tdr_data_in[211]:I tdr_data_in[210]:I tdr_data_in[209]:I tdr_data_in[208]:I tdr_data_in[207]:I tdr_data_in[206]:I tdr_data_in[205]:I
* .PININFO tdr_data_in[204]:I tdr_data_in[203]:I tdr_data_in[202]:I tdr_data_in[201]:I tdr_data_in[200]:I tdr_data_in[199]:I tdr_data_in[198]:I
* .PININFO tdr_data_in[197]:I tdr_data_in[196]:I tdr_data_in[195]:I tdr_data_in[194]:I tdr_data_in[193]:I tdr_data_in[192]:I tdr_data_in[191]:I
* .PININFO tdr_data_in[190]:I tdr_data_in[189]:I tdr_data_in[188]:I tdr_data_in[187]:I tdr_data_in[186]:I tdr_data_in[185]:I tdr_data_in[184]:I
* .PININFO tdr_data_in[183]:I tdr_data_in[182]:I tdr_data_in[181]:I tdr_data_in[180]:I tdr_data_in[179]:I tdr_data_in[178]:I tdr_data_in[177]:I
* .PININFO tdr_data_in[176]:I tdr_data_in[175]:I tdr_data_in[174]:I tdr_data_in[173]:I tdr_data_in[172]:I tdr_data_in[171]:I tdr_data_in[170]:I
* .PININFO tdr_data_in[169]:I tdr_data_in[168]:I tdr_data_in[167]:I tdr_data_in[166]:I tdr_data_in[165]:I tdr_data_in[164]:I tdr_data_in[163]:I
* .PININFO tdr_data_in[162]:I tdr_data_in[161]:I tdr_data_in[160]:I tdr_data_in[159]:I tdr_data_in[158]:I tdr_data_in[157]:I tdr_data_in[156]:I
* .PININFO tdr_data_in[155]:I tdr_data_in[154]:I tdr_data_in[153]:I tdr_data_in[152]:I tdr_data_in[151]:I tdr_data_in[150]:I tdr_data_in[149]:I
* .PININFO tdr_data_in[148]:I tdr_data_in[147]:I tdr_data_in[146]:I tdr_data_in[145]:I tdr_data_in[144]:I tdr_data_in[143]:I tdr_data_in[142]:I
* .PININFO tdr_data_in[141]:I tdr_data_in[140]:I tdr_data_in[139]:I tdr_data_in[138]:I tdr_data_in[137]:I tdr_data_in[136]:I tdr_data_in[135]:I
* .PININFO tdr_data_in[134]:I tdr_data_in[133]:I tdr_data_in[132]:I tdr_data_in[131]:I tdr_data_in[130]:I tdr_data_in[129]:I tdr_data_in[128]:I
* .PININFO tdr_data_in[127]:I tdr_data_in[126]:I tdr_data_in[125]:I tdr_data_in[124]:I tdr_data_in[123]:I tdr_data_in[122]:I tdr_data_in[121]:I
* .PININFO tdr_data_in[120]:I tdr_data_in[119]:I tdr_data_in[118]:I tdr_data_in[117]:I tdr_data_in[116]:I tdr_data_in[115]:I tdr_data_in[114]:I
* .PININFO tdr_data_in[113]:I tdr_data_in[112]:I tdr_data_in[111]:I tdr_data_in[110]:I tdr_data_in[109]:I tdr_data_in[108]:I tdr_data_in[107]:I
* .PININFO tdr_data_in[106]:I tdr_data_in[105]:I tdr_data_in[104]:I tdr_data_in[103]:I tdr_data_in[102]:I tdr_data_in[101]:I tdr_data_in[100]:I
* .PININFO tdr_data_in[99]:I tdr_data_in[98]:I tdr_data_in[97]:I tdr_data_in[96]:I tdr_data_in[95]:I tdr_data_in[94]:I tdr_data_in[93]:I
* .PININFO tdr_data_in[92]:I tdr_data_in[91]:I tdr_data_in[90]:I tdr_data_in[89]:I tdr_data_in[88]:I tdr_data_in[87]:I tdr_data_in[86]:I
* .PININFO tdr_data_in[85]:I tdr_data_in[84]:I tdr_data_in[83]:I tdr_data_in[82]:I tdr_data_in[81]:I tdr_data_in[80]:I tdr_data_in[79]:I
* .PININFO tdr_data_in[78]:I tdr_data_in[77]:I tdr_data_in[76]:I tdr_data_in[75]:I tdr_data_in[74]:I tdr_data_in[73]:I tdr_data_in[72]:I
* .PININFO tdr_data_in[71]:I tdr_data_in[70]:I tdr_data_in[69]:I tdr_data_in[68]:I tdr_data_in[67]:I tdr_data_in[66]:I tdr_data_in[65]:I
* .PININFO tdr_data_in[64]:I tdr_data_in[63]:I tdr_data_in[62]:I tdr_data_in[61]:I tdr_data_in[60]:I tdr_data_in[59]:I tdr_data_in[58]:I
* .PININFO tdr_data_in[57]:I tdr_data_in[56]:I tdr_data_in[55]:I tdr_data_in[54]:I tdr_data_in[53]:I tdr_data_in[52]:I tdr_data_in[51]:I
* .PININFO tdr_data_in[50]:I tdr_data_in[49]:I tdr_data_in[48]:I tdr_data_in[47]:I tdr_data_in[46]:I tdr_data_in[45]:I tdr_data_in[44]:I
* .PININFO tdr_data_in[43]:I tdr_data_in[42]:I tdr_data_in[41]:I tdr_data_in[40]:I tdr_data_in[39]:I tdr_data_in[38]:I tdr_data_in[37]:I
* .PININFO tdr_data_in[36]:I tdr_data_in[35]:I tdr_data_in[34]:I tdr_data_in[33]:I tdr_data_in[32]:I tdr_data_in[31]:I tdr_data_in[30]:I
* .PININFO tdr_data_in[29]:I tdr_data_in[28]:I tdr_data_in[27]:I tdr_data_in[26]:I tdr_data_in[25]:I tdr_data_in[24]:I tdr_data_in[23]:I
* .PININFO tdr_data_in[22]:I tdr_data_in[21]:I tdr_data_in[20]:I tdr_data_in[19]:I tdr_data_in[18]:I tdr_data_in[17]:I tdr_data_in[16]:I
* .PININFO tdr_data_in[15]:I tdr_data_in[14]:I tdr_data_in[13]:I tdr_data_in[12]:I tdr_data_in[11]:I tdr_data_in[10]:I tdr_data_in[9]:I
* .PININFO tdr_data_in[8]:I tdr_data_in[7]:I tdr_data_in[6]:I tdr_data_in[5]:I tdr_data_in[4]:I tdr_data_in[3]:I tdr_data_in[2]:I tdr_data_in[1]:I
* .PININFO tdr_data_in[0]:I vdd:I vssx:I data_reg_tdo:O p_abuf0:O p_abuf1:O p_abuf2:O p_abuf3:O p_abuf4:O p_abuf5:O p_abuf6:O p_abuf7:O p_abuf8:O
* .PININFO p_abuf9:O p_abuf10:O p_abuf11:O p_abuf12:O p_abuf13:O p_abuf14:O p_abuf15:O p_abuf70:O p_abuf71:O tdr_data_out[268]:O tdr_data_out[267]:O
* .PININFO tdr_data_out[266]:O tdr_data_out[265]:O tdr_data_out[264]:O tdr_data_out[263]:O tdr_data_out[262]:O tdr_data_out[261]:O tdr_data_out[260]:O
* .PININFO tdr_data_out[259]:O tdr_data_out[258]:O tdr_data_out[257]:O tdr_data_out[256]:O tdr_data_out[255]:O tdr_data_out[254]:O tdr_data_out[253]:O
* .PININFO tdr_data_out[252]:O tdr_data_out[251]:O tdr_data_out[250]:O tdr_data_out[249]:O tdr_data_out[248]:O tdr_data_out[247]:O tdr_data_out[246]:O
* .PININFO tdr_data_out[245]:O tdr_data_out[244]:O tdr_data_out[243]:O tdr_data_out[242]:O tdr_data_out[241]:O tdr_data_out[240]:O tdr_data_out[239]:O
* .PININFO tdr_data_out[238]:O tdr_data_out[237]:O tdr_data_out[236]:O tdr_data_out[235]:O tdr_data_out[234]:O tdr_data_out[233]:O tdr_data_out[232]:O
* .PININFO tdr_data_out[231]:O tdr_data_out[230]:O tdr_data_out[229]:O tdr_data_out[228]:O tdr_data_out[227]:O tdr_data_out[226]:O tdr_data_out[225]:O
* .PININFO tdr_data_out[224]:O tdr_data_out[223]:O tdr_data_out[222]:O tdr_data_out[221]:O tdr_data_out[220]:O tdr_data_out[219]:O tdr_data_out[218]:O
* .PININFO tdr_data_out[217]:O tdr_data_out[216]:O tdr_data_out[215]:O tdr_data_out[214]:O tdr_data_out[213]:O tdr_data_out[212]:O tdr_data_out[211]:O
* .PININFO tdr_data_out[210]:O tdr_data_out[209]:O tdr_data_out[208]:O tdr_data_out[207]:O tdr_data_out[206]:O tdr_data_out[205]:O tdr_data_out[204]:O
* .PININFO tdr_data_out[203]:O tdr_data_out[202]:O tdr_data_out[201]:O tdr_data_out[200]:O tdr_data_out[199]:O tdr_data_out[198]:O tdr_data_out[197]:O
* .PININFO tdr_data_out[196]:O tdr_data_out[195]:O tdr_data_out[194]:O tdr_data_out[193]:O tdr_data_out[192]:O tdr_data_out[191]:O tdr_data_out[190]:O
* .PININFO tdr_data_out[189]:O tdr_data_out[188]:O tdr_data_out[187]:O tdr_data_out[186]:O tdr_data_out[185]:O tdr_data_out[184]:O tdr_data_out[183]:O
* .PININFO tdr_data_out[182]:O tdr_data_out[181]:O tdr_data_out[180]:O tdr_data_out[179]:O tdr_data_out[178]:O tdr_data_out[177]:O tdr_data_out[176]:O
* .PININFO tdr_data_out[175]:O tdr_data_out[174]:O tdr_data_out[173]:O tdr_data_out[172]:O tdr_data_out[171]:O tdr_data_out[170]:O tdr_data_out[169]:O
* .PININFO tdr_data_out[168]:O tdr_data_out[167]:O tdr_data_out[166]:O tdr_data_out[165]:O tdr_data_out[164]:O tdr_data_out[163]:O tdr_data_out[162]:O
* .PININFO tdr_data_out[161]:O tdr_data_out[160]:O tdr_data_out[159]:O tdr_data_out[158]:O tdr_data_out[157]:O tdr_data_out[156]:O tdr_data_out[155]:O
* .PININFO tdr_data_out[154]:O tdr_data_out[153]:O tdr_data_out[152]:O tdr_data_out[151]:O tdr_data_out[150]:O tdr_data_out[149]:O tdr_data_out[148]:O
* .PININFO tdr_data_out[147]:O tdr_data_out[146]:O tdr_data_out[145]:O tdr_data_out[144]:O tdr_data_out[143]:O tdr_data_out[142]:O tdr_data_out[141]:O
* .PININFO tdr_data_out[140]:O tdr_data_out[139]:O tdr_data_out[138]:O tdr_data_out[137]:O tdr_data_out[136]:O tdr_data_out[135]:O tdr_data_out[134]:O
* .PININFO tdr_data_out[133]:O tdr_data_out[132]:O tdr_data_out[131]:O tdr_data_out[130]:O tdr_data_out[129]:O tdr_data_out[128]:O tdr_data_out[127]:O
* .PININFO tdr_data_out[126]:O tdr_data_out[125]:O tdr_data_out[124]:O tdr_data_out[123]:O tdr_data_out[122]:O tdr_data_out[121]:O tdr_data_out[120]:O
* .PININFO tdr_data_out[119]:O tdr_data_out[118]:O tdr_data_out[117]:O tdr_data_out[116]:O tdr_data_out[115]:O tdr_data_out[114]:O tdr_data_out[113]:O
* .PININFO tdr_data_out[112]:O tdr_data_out[111]:O tdr_data_out[110]:O tdr_data_out[109]:O tdr_data_out[108]:O tdr_data_out[107]:O tdr_data_out[106]:O
* .PININFO tdr_data_out[105]:O tdr_data_out[104]:O tdr_data_out[103]:O tdr_data_out[102]:O tdr_data_out[101]:O tdr_data_out[100]:O tdr_data_out[99]:O
* .PININFO tdr_data_out[98]:O tdr_data_out[97]:O tdr_data_out[96]:O tdr_data_out[95]:O tdr_data_out[94]:O tdr_data_out[93]:O tdr_data_out[92]:O
* .PININFO tdr_data_out[91]:O tdr_data_out[90]:O tdr_data_out[89]:O tdr_data_out[88]:O tdr_data_out[87]:O tdr_data_out[86]:O tdr_data_out[85]:O
* .PININFO tdr_data_out[84]:O tdr_data_out[83]:O tdr_data_out[82]:O tdr_data_out[81]:O tdr_data_out[80]:O tdr_data_out[79]:O tdr_data_out[78]:O
* .PININFO tdr_data_out[77]:O tdr_data_out[76]:O tdr_data_out[75]:O tdr_data_out[74]:O tdr_data_out[73]:O tdr_data_out[72]:O tdr_data_out[71]:O
* .PININFO tdr_data_out[70]:O tdr_data_out[69]:O tdr_data_out[68]:O tdr_data_out[67]:O tdr_data_out[66]:O tdr_data_out[65]:O tdr_data_out[64]:O
* .PININFO tdr_data_out[63]:O tdr_data_out[62]:O tdr_data_out[61]:O tdr_data_out[60]:O tdr_data_out[59]:O tdr_data_out[58]:O tdr_data_out[57]:O
* .PININFO tdr_data_out[56]:O tdr_data_out[55]:O tdr_data_out[54]:O tdr_data_out[53]:O tdr_data_out[52]:O tdr_data_out[51]:O tdr_data_out[50]:O
* .PININFO tdr_data_out[49]:O tdr_data_out[48]:O tdr_data_out[47]:O tdr_data_out[46]:O tdr_data_out[45]:O tdr_data_out[44]:O tdr_data_out[43]:O
* .PININFO tdr_data_out[42]:O tdr_data_out[41]:O tdr_data_out[40]:O tdr_data_out[39]:O tdr_data_out[38]:O tdr_data_out[37]:O tdr_data_out[36]:O
* .PININFO tdr_data_out[35]:O tdr_data_out[34]:O tdr_data_out[33]:O tdr_data_out[32]:O tdr_data_out[31]:O tdr_data_out[30]:O tdr_data_out[29]:O
* .PININFO tdr_data_out[28]:O tdr_data_out[27]:O tdr_data_out[26]:O tdr_data_out[25]:O tdr_data_out[24]:O tdr_data_out[23]:O tdr_data_out[22]:O
* .PININFO tdr_data_out[21]:O tdr_data_out[20]:O tdr_data_out[19]:O tdr_data_out[18]:O tdr_data_out[17]:O tdr_data_out[16]:O tdr_data_out[15]:O
* .PININFO tdr_data_out[14]:O tdr_data_out[13]:O tdr_data_out[12]:O tdr_data_out[11]:O tdr_data_out[10]:O tdr_data_out[9]:O tdr_data_out[8]:O
* .PININFO tdr_data_out[7]:O tdr_data_out[6]:O tdr_data_out[5]:O tdr_data_out[4]:O tdr_data_out[3]:O tdr_data_out[2]:O tdr_data_out[1]:O
* .PININFO tdr_data_out[0]:O
Xtdr_data_out_reg[5] ftap_tck n1310 tdr_data_out[5] p49 p_abuf93 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[21] p_abuf100 n4500 tdr_data_out[21] p2 reset_b vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[87] p_abuf99 n1770 tdr_data_out[87] p24 p_abuf79 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[12] p_abuf98 n2790 tdr_data_out[12] p16 p_abuf55 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[175] p_abuf101 n353 tdr_data_out[175] p6 p_abuf49 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[113] p_abuf97 n2290 tdr_data_out[113] p60 p_abuf68 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[143] ftap_tck n289 tdr_data_out[143] p44 p_abuf93 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[146] ftap_tck n295 tdr_data_out[146] p44 p_abuf93 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[162] p_abuf102 n327 tdr_data_out[162] p8 p_abuf17 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[124] p_abuf103 n2511 tdr_data_out[124] p41 p_abuf91 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[141] p_abuf98 n285 tdr_data_out[141] p53 p_abuf57 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[61] p_abuf100 n1250 tdr_data_out[61] p28 p_abuf48 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[59] p_abuf100 n1210 tdr_data_out[59] p28 p_abuf48 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[13] p_abuf100 n2900 tdr_data_out[13] p33 p_abuf96 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[96] p_abuf97 n1950 tdr_data_out[96] p50 p_abuf90 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[148] p_abuf100 n299 tdr_data_out[148] p32 p_abuf94 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[57] p_abuf100 n1170 tdr_data_out[57] p29 p_abuf64 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[121] p_abuf97 n2450 tdr_data_out[121] p41 p_abuf61 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[115] p_abuf97 n2330 tdr_data_out[115] p60 p_abuf83 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[144] ftap_tck n291 tdr_data_out[144] p44 p_abuf93 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[178] p_abuf103 n359 tdr_data_out[178] p26 p_abuf33 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[186] p_abuf103 n375 tdr_data_out[186] p21 p_abuf53 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[182] p_abuf103 n367 tdr_data_out[182] p21 p_abuf53 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[174] p_abuf103 n351 tdr_data_out[174] p54 p_abuf33 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[170] p_abuf103 n343 tdr_data_out[170] p26 p_abuf33 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[181] p_abuf103 n365 tdr_data_out[181] p21 p_abuf49 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[99] p_abuf101 n2010 tdr_data_out[99] p14 reset_b vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[149] p_abuf98 n301 tdr_data_out[149] p43 p_abuf85 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[151] p_abuf98 n305 tdr_data_out[151] p43 p_abuf85 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[97] p_abuf101 n1970 tdr_data_out[97] p14 reset_b vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[69] p_abuf100 n1410 tdr_data_out[69] p34 p_abuf52 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[184] p_abuf103 n371 tdr_data_out[184] p54 p_abuf23 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[173] p_abuf101 n349 tdr_data_out[173] p6 p_abuf49 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[15] p_abuf100 n330 tdr_data_out[15] p1 p_abuf16 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[158] p_abuf102 n319 tdr_data_out[158] p40 p_abuf73 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[110] p_abuf101 n2230 tdr_data_out[110] p15 p_abuf89 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[105] p_abuf103 n2130 tdr_data_out[105] p38 p_abuf67 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[171] p_abuf103 n345 tdr_data_out[171] p26 p_abuf33 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[196] p_abuf102 n395 tdr_data_out[196] p47 p_abuf80 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[147] ftap_tck n297 tdr_data_out[147] p44 p_abuf93 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[192] p_abuf103 n387 tdr_data_out[192] p22 p_abuf29 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[200] p_abuf102 n403 tdr_data_out[200] p47 p_abuf81 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[78] p_abuf98 n1590 tdr_data_out[78] p52 p_abuf32 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[58] p_abuf100 n1190 tdr_data_out[58] p29 p_abuf64 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[118] p_abuf99 n2390 tdr_data_out[118] p46 p_abuf61 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[98] p_abuf100 n1990 tdr_data_out[98] p2 reset_b vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[102] p_abuf101 n2070 tdr_data_out[102] p14 reset_b vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[62] ftap_tck n1270 tdr_data_out[62] p28 p_abuf72 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[64] ftap_tck n1311 tdr_data_out[64] p28 p_abuf52 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[156] p_abuf99 n315 tdr_data_out[156] p18 p_abuf18 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[163] p_abuf102 n329 tdr_data_out[163] p8 p_abuf17 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[4] ftap_tck n11 tdr_data_out[4] p27 p_abuf93 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[159] p_abuf99 n321 tdr_data_out[159] p40 p_abuf73 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[88] p_abuf99 n1790 tdr_data_out[88] p24 p_abuf79 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[106] p_abuf101 n2150 tdr_data_out[106] p37 p_abuf66 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[18] p_abuf100 n390 tdr_data_out[18] p2 reset_b vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[109] p_abuf101 n2210 tdr_data_out[109] p5 p_abuf92 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[126] p_abuf99 n2550 tdr_data_out[126] p23 p_abuf50 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[84] p_abuf98 n1711 tdr_data_out[84] p10 p_abuf35 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[81] p_abuf98 n1650 tdr_data_out[81] p51 p_abuf32 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[154] p_abuf98 n311 tdr_data_out[154] p7 p_abuf43 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[79] p_abuf98 n1610 tdr_data_out[79] p7 p_abuf43 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[142] p_abuf100 n287 tdr_data_out[142] p32 p_abuf94 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[10] p_abuf98 n2310 tdr_data_out[10] p7 p_abuf32 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[131] p_abuf99 n2650 tdr_data_out[131] p17 p_abuf78 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[70] p_abuf100 n1430 tdr_data_out[70] p29 p_abuf48 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[35] p_abuf97 n730 tdr_data_out[35] p59 p_abuf61 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[122] p_abuf97 n2470 tdr_data_out[122] p41 p_abuf91 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[130] p_abuf103 n2630 tdr_data_out[130] p23 p_abuf42 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[206] p_abuf102 n415 tdr_data_out[206] p30 p_abuf74 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[83] p_abuf99 n1690 tdr_data_out[83] p13 p_abuf77 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[155] p_abuf98 n313 tdr_data_out[155] p52 p_abuf32 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[195] p_abuf103 n393 tdr_data_out[195] p48 p_abuf29 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[0] p_abuf100 n3 tdr_data_out[0] p32 p_abuf94 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[191] p_abuf102 n385 tdr_data_out[191] p22 p_abuf75 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[66] p_abuf100 n1350 tdr_data_out[66] p34 p_abuf94 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[188] p_abuf101 n379 tdr_data_out[188] p21 p_abuf53 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[63] p_abuf100 n1290 tdr_data_out[63] p35 p_abuf72 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[169] p_abuf103 n341 tdr_data_out[169] p54 p_abuf23 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[31] p_abuf101 n650 tdr_data_out[31] p9 p_abuf88 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[180] p_abuf103 n363 tdr_data_out[180] p6 p_abuf49 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[177] p_abuf101 n357 tdr_data_out[177] p6 p_abuf49 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[201] p_abuf102 n405 tdr_data_out[201] p31 p_abuf74 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[183] p_abuf103 n369 tdr_data_out[183] p55 p_abuf24 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[185] p_abuf103 n373 tdr_data_out[185] p55 p_abuf24 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[187] p_abuf101 n377 tdr_data_out[187] p21 p_abuf53 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[94] p_abuf100 n1911 tdr_data_out[94] p2 p_abuf16 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[24] p_abuf101 n510 tdr_data_out[24] p14 reset_b vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[198] p_abuf103 n399 tdr_data_out[198] p48 p_abuf29 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[85] p_abuf98 n1730 tdr_data_out[85] p13 p_abuf77 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[17] p_abuf97 n3700 tdr_data_out[17] p50 p_abuf90 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[125] p_abuf103 n2530 tdr_data_out[125] p23 p_abuf42 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[117] p_abuf97 n2370 tdr_data_out[117] p59 p_abuf61 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[44] p_abuf97 n910 tdr_data_out[44] p19 p_abuf44 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[108] p_abuf101 n2190 tdr_data_out[108] p5 p_abuf89 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[167] p_abuf103 n337 tdr_data_out[167] p38 p_abuf66 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[114] p_abuf101 n2311 tdr_data_out[114] p50 p_abuf90 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[30] p_abuf101 n630 tdr_data_out[30] p9 p_abuf88 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[32] p_abuf101 n670 tdr_data_out[32] p14 reset_b vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[49] p_abuf97 n1010 tdr_data_out[49] p58 p_abuf87 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[7] p_abuf98 n1710 tdr_data_out[7] p43 p_abuf85 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[197] p_abuf103 n397 tdr_data_out[197] p22 p_abuf29 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[190] p_abuf103 n383 tdr_data_out[190] p47 p_abuf80 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[194] p_abuf102 n391 tdr_data_out[194] p47 p_abuf80 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[40] p_abuf98 n830 tdr_data_out[40] p7 p_abuf43 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[53] p_abuf97 n1090 tdr_data_out[53] p57 p_abuf90 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[153] p_abuf98 n309 tdr_data_out[153] p7 p_abuf43 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[86] p_abuf99 n1750 tdr_data_out[86] p10 p_abuf35 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[150] p_abuf98 n303 tdr_data_out[150] p45 p_abuf85 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[29] p_abuf101 n610 tdr_data_out[29] p15 p_abuf88 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[80] p_abuf98 n1630 tdr_data_out[80] p13 p_abuf32 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[103] p_abuf101 n2090 tdr_data_out[103] p5 p_abuf66 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[23] p_abuf100 n4900 tdr_data_out[23] p42 p_abuf90 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[168] p_abuf103 n339 tdr_data_out[168] p37 p_abuf66 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[172] p_abuf103 n347 tdr_data_out[172] p26 p_abuf33 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[50] p_abuf97 n1030 tdr_data_out[50] p57 p_abuf87 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[54] p_abuf100 n1110 tdr_data_out[54] p57 p_abuf87 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[56] p_abuf100 n1150 tdr_data_out[56] p29 p_abuf96 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[55] p_abuf100 n1130 tdr_data_out[55] p57 p_abuf87 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[14] p_abuf100 n310 tdr_data_out[14] p1 p_abuf16 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[16] p_abuf100 n3500 tdr_data_out[16] p1 p_abuf16 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[19] p_abuf100 n4100 tdr_data_out[19] p1 p_abuf16 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[165] p_abuf103 n333 tdr_data_out[165] p38 p_abuf67 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[36] p_abuf101 n750 tdr_data_out[36] p5 p_abuf89 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[33] p_abuf101 n690 tdr_data_out[33] p15 p_abuf88 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[120] p_abuf99 n2430 tdr_data_out[120] p46 p_abuf61 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[90] p_abuf99 n1830 tdr_data_out[90] p24 p_abuf79 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[1] p_abuf100 n5 tdr_data_out[1] p32 p_abuf94 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[3] ftap_tck n9 tdr_data_out[3] p27 p_abuf93 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[133] p_abuf102 n2690 tdr_data_out[133] p36 p_abuf73 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[60] p_abuf100 n1230 tdr_data_out[60] p33 p_abuf96 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[116] p_abuf97 n2350 tdr_data_out[116] p41 p_abuf61 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[145] ftap_tck n293 tdr_data_out[145] p49 p_abuf93 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[22] p_abuf100 n470 tdr_data_out[22] p1 p_abuf16 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[119] p_abuf97 n2410 tdr_data_out[119] p41 p_abuf91 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[112] p_abuf97 n2270 tdr_data_out[112] p50 p_abuf90 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[27] p_abuf101 n570 tdr_data_out[27] p12 p_abuf89 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[101] p_abuf97 n2050 tdr_data_out[101] p50 p_abuf90 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[166] p_abuf103 n335 tdr_data_out[166] p37 p_abuf67 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[28] p_abuf101 n590 tdr_data_out[28] p9 p_abuf88 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[107] p_abuf101 n2170 tdr_data_out[107] p37 p_abuf89 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[20] p_abuf100 n4300 tdr_data_out[20] p42 p_abuf95 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[25] p_abuf101 n530 tdr_data_out[25] p12 p_abuf89 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[111] p_abuf97 n2250 tdr_data_out[111] p60 p_abuf62 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[26] p_abuf101 n550 tdr_data_out[26] p12 p_abuf89 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[65] p_abuf100 n1330 tdr_data_out[65] p35 p_abuf65 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[199] p_abuf102 n401 tdr_data_out[199] p31 p_abuf36 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[204] p_abuf102 n411 tdr_data_out[204] p30 p_abuf74 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[203] p_abuf102 n409 tdr_data_out[203] p30 p_abuf39 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[2] ftap_tck n7 tdr_data_out[2] p27 p_abuf93 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[67] ftap_tck n1370 tdr_data_out[67] p35 p_abuf48 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[193] p_abuf103 n389 tdr_data_out[193] p22 p_abuf75 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[138] p_abuf102 n2791 tdr_data_out[138] p61 p_abuf39 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[8] p_abuf98 n1910 tdr_data_out[8] p43 p_abuf85 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[68] p_abuf100 n1390 tdr_data_out[68] p33 p_abuf48 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[202] p_abuf102 n407 tdr_data_out[202] p31 p_abuf39 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[205] p_abuf102 n413 tdr_data_out[205] p30 p_abuf74 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[152] p_abuf98 n307 tdr_data_out[152] p45 p_abuf85 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[95] p_abuf100 n1930 tdr_data_out[95] p2 p_abuf38 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[46] p_abuf97 n950 tdr_data_out[46] p19 p_abuf44 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[91] p_abuf99 n1850 tdr_data_out[91] p17 p_abuf78 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[47] p_abuf97 n970 tdr_data_out[47] p19 p_abuf86 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[37] p_abuf97 n770 tdr_data_out[37] p58 p_abuf87 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[6] p_abuf98 n1510 tdr_data_out[6] p43 p_abuf85 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[34] p_abuf97 n710 tdr_data_out[34] p60 p_abuf82 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[93] p_abuf97 n1890 tdr_data_out[93] p60 p_abuf82 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[11] p_abuf98 n2510 tdr_data_out[11] p53 p_abuf20 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[75] p_abuf98 n1530 tdr_data_out[75] p53 p_abuf20 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[77] p_abuf98 n1570 tdr_data_out[77] p53 p_abuf59 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[72] p_abuf100 n1470 tdr_data_out[72] p20 p_abuf64 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[52] p_abuf98 n1070 tdr_data_out[52] p56 p_abuf87 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[73] p_abuf98 n1490 tdr_data_out[73] p20 p_abuf64 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[71] p_abuf100 n1450 tdr_data_out[71] p20 p_abuf64 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[74] p_abuf100 n1511 tdr_data_out[74] p20 p_abuf64 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[76] p_abuf98 n1550 tdr_data_out[76] p56 p_abuf59 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[140] p_abuf97 n283 tdr_data_out[140] p56 p_abuf59 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[42] p_abuf97 n870 tdr_data_out[42] p25 p_abuf79 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[41] p_abuf98 n850 tdr_data_out[41] p16 p_abuf35 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[38] p_abuf97 n790 tdr_data_out[38] p16 p_abuf35 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[39] p_abuf97 n810 tdr_data_out[39] p16 p_abuf35 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[43] p_abuf97 n890 tdr_data_out[43] p25 p_abuf79 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[48] p_abuf97 n990 tdr_data_out[48] p56 p_abuf87 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[139] p_abuf97 n281 tdr_data_out[139] p56 p_abuf87 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[100] p_abuf97 n2030 tdr_data_out[100] p25 p_abuf58 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[51] p_abuf97 n1050 tdr_data_out[51] p25 p_abuf58 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[92] p_abuf99 n1870 tdr_data_out[92] p17 p_abuf58 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[45] p_abuf99 n930 tdr_data_out[45] p17 p_abuf56 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[89] p_abuf99 n1810 tdr_data_out[89] p24 p_abuf79 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[123] p_abuf99 n2490 tdr_data_out[123] p46 p_abuf61 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[132] p_abuf103 n2670 aps_rename_1434 p39 p_abuf47 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[189] p_abuf103 n381 aps_rename_1433 p54 p_abuf23 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[134] p_abuf102 n2710 tdr_data_out[134] p36 p_abuf73 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[161] p_abuf102 n325 tdr_data_out[161] p8 p_abuf27 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[137] p_abuf102 n2770 tdr_data_out[137] p18 p_abuf73 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[9] ftap_tck n2110 tdr_data_out[9] p49 p_abuf93 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[136] p_abuf102 n2750 tdr_data_out[136] p8 p_abuf17 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[160] p_abuf102 n323 tdr_data_out[160] p36 p_abuf73 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[176] p_abuf101 n355 tdr_data_out[176] p6 p_abuf49 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[135] p_abuf102 n2730 tdr_data_out[135] p8 p_abuf17 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[157] p_abuf99 n317 tdr_data_out[157] p18 p_abuf18 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[164] p_abuf99 n331 tdr_data_out[164] p18 p_abuf18 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[179] p_abuf101 n361 tdr_data_out[179] p26 p_abuf33 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xtdr_data_out_reg[82] p_abuf98 n1670 tdr_data_out[82] p10 p_abuf35 vdd vssx ringpll__b15fqn08fal1n02x5 m=1
Xu310 shift_register[239] buf_net_457 buf_net_435 tdr_data_in[238] n248 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu14 buf_net_422 shift_register[132] buft_net_133 p_abuf11 n2670 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu355 buf_net_421 shift_register[189] buft_net_125 p_abuf71 n381 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu675 shift_register[228] buf_net_459 buf_net_440 tdr_data_in[227] n237 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu302 shift_register[227] buf_net_452 buf_net_440 tdr_data_in[226] n236 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu477 buf_net_416 shift_register[56] buft_net_135 tdr_data_out[56] n1150 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu609 buf_net_416 shift_register[57] buft_net_135 tdr_data_out[57] n1170 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu562 buf_net_424 shift_register[167] buft_net_132 tdr_data_out[167] n337 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu538 buf_net_424 shift_register[168] buft_net_132 tdr_data_out[168] n339 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu659 buf_net_425 shift_register[6] buft_net_130 tdr_data_out[6] n1510 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu541 buf_net_424 shift_register[108] buft_net_132 tdr_data_out[108] n2190 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu526 buf_net_424 shift_register[103] buft_net_132 tdr_data_out[103] n2090 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu625 buf_net_425 shift_register[152] buft_net_131 tdr_data_out[152] n307 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu631 buf_net_425 shift_register[150] buft_net_131 tdr_data_out[150] n303 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu495 buf_net_429 shift_register[17] buft_net_122 tdr_data_out[17] n3700 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu510 buf_net_429 shift_register[29] buft_net_122 tdr_data_out[29] n610 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu657 buf_net_425 shift_register[8] buft_net_131 tdr_data_out[8] n1910 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu658 buf_net_425 shift_register[7] buft_net_131 tdr_data_out[7] n1710 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu544 buf_net_429 shift_register[110] buft_net_122 tdr_data_out[110] n2230 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu499 buf_net_429 shift_register[33] buft_net_122 tdr_data_out[33] n690 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu677 shift_register[223] buf_net_450 buf_net_437 tdr_data_in[222] n232 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu41 shift_register[261] buf_net_449 buf_net_438 tdr_data_in[260] n270 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu309 shift_register[225] buf_net_445 buf_net_436 tdr_data_in[224] n234 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu45 shift_register[255] buf_net_449 buf_net_438 tdr_data_in[254] n264 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu550 buf_net_429 shift_register[113] buft_net_122 tdr_data_out[113] n2290 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu521 buf_net_429 shift_register[96] buft_net_122 tdr_data_out[96] n1950 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu507 buf_net_429 shift_register[31] buft_net_122 tdr_data_out[31] n650 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu548 buf_net_429 shift_register[112] buft_net_122 tdr_data_out[112] n2270 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu552 buf_net_429 shift_register[114] buft_net_122 tdr_data_out[114] n2311 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu529 buf_net_429 shift_register[101] buft_net_122 tdr_data_out[101] n2050 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu508 buf_net_429 shift_register[30] buft_net_122 tdr_data_out[30] n630 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu511 buf_net_429 shift_register[28] buft_net_122 tdr_data_out[28] n590 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu503 buf_net_429 shift_register[32] buft_net_122 tdr_data_out[32] n670 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu311 buf_net_437 tdr_data_in[268] buf_net_450 ftap_tdi n278 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu676 shift_register[266] buf_net_450 buf_net_437 tdr_data_in[265] n275 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu44 shift_register[254] buf_net_451 buf_net_438 tdr_data_in[253] n263 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu35 shift_register[256] buf_net_449 buf_net_438 tdr_data_in[255] n265 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu674 shift_register[268] buf_net_451 buf_net_437 tdr_data_in[267] n277 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu42 shift_register[253] buf_net_451 buf_net_438 tdr_data_in[252] n262 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu40 shift_register[252] buf_net_451 buf_net_438 tdr_data_in[251] n261 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu679 shift_register[241] buf_net_449 buf_net_439 tdr_data_in[240] n250 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu687 shift_register[249] buf_net_454 buf_net_439 tdr_data_in[248] n258 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu683 shift_register[245] buf_net_456 buf_net_439 tdr_data_in[244] n254 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu682 shift_register[244] buf_net_456 buf_net_439 tdr_data_in[243] n253 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu36 shift_register[264] buf_net_450 buf_net_437 tdr_data_in[263] n273 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu308 shift_register[226] buf_net_454 buf_net_439 tdr_data_in[225] n235 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu678 shift_register[224] buf_net_449 buf_net_439 tdr_data_in[223] n233 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu300 shift_register[229] buf_net_443 buf_net_435 tdr_data_in[228] n238 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu83 shift_register[238] buf_net_443 buf_net_435 tdr_data_in[237] n247 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu38 shift_register[265] buf_net_450 buf_net_437 tdr_data_in[264] n274 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu86 shift_register[240] buf_net_450 buf_net_437 tdr_data_in[239] n249 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu689 shift_register[251] buf_net_454 buf_net_439 tdr_data_in[250] n260 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu688 shift_register[250] buf_net_454 buf_net_439 tdr_data_in[249] n259 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu686 shift_register[248] buf_net_454 buf_net_439 tdr_data_in[247] n257 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu684 shift_register[246] buf_net_454 buf_net_439 tdr_data_in[245] n255 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu681 shift_register[243] buf_net_454 buf_net_439 tdr_data_in[242] n252 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu680 shift_register[242] buf_net_454 buf_net_439 tdr_data_in[241] n251 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu685 shift_register[247] buf_net_454 buf_net_439 tdr_data_in[246] n256 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu127 shift_register[230] buf_net_443 buf_net_435 tdr_data_in[229] n239 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu73 shift_register[235] buf_net_443 buf_net_435 tdr_data_in[234] n244 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu77 shift_register[236] buf_net_443 buf_net_435 tdr_data_in[235] n245 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu79 shift_register[237] buf_net_443 buf_net_435 tdr_data_in[236] n246 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu60 shift_register[231] buf_net_443 buf_net_435 tdr_data_in[230] n240 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu67 shift_register[232] buf_net_443 buf_net_435 tdr_data_in[231] n241 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu71 shift_register[234] buf_net_443 buf_net_435 tdr_data_in[233] n243 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu69 shift_register[233] buf_net_443 buf_net_435 tdr_data_in[232] n242 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xins_eco_199 eco_net_3_0 shift_register[80] tdr_data_in[79] eco_net n89 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu500 buf_net_429 shift_register[20] buft_net_134 tdr_data_out[20] n4300 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu607 buf_net_429 shift_register[53] buft_net_134 tdr_data_out[53] n1090 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu39 shift_register[262] buf_net_449 buf_net_438 tdr_data_in[261] n271 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu46 shift_register[260] buf_net_449 buf_net_438 tdr_data_in[259] n269 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu33 shift_register[257] buf_net_449 buf_net_438 tdr_data_in[256] n266 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu43 shift_register[259] buf_net_449 buf_net_438 tdr_data_in[258] n268 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu37 shift_register[263] buf_net_449 buf_net_438 tdr_data_in[262] n272 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu47 shift_register[258] buf_net_449 buf_net_438 tdr_data_in[257] n267 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu615 buf_net_429 shift_register[50] buft_net_134 tdr_data_out[50] n1030 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu612 buf_net_429 shift_register[54] buft_net_134 tdr_data_out[54] n1110 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu578 buf_net_429 shift_register[55] buft_net_134 tdr_data_out[55] n1130 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu490 buf_net_416 shift_register[14] buft_net_134 tdr_data_out[14] n310 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu546 buf_net_424 shift_register[111] buft_net_132 tdr_data_out[111] n2250 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu553 buf_net_424 shift_register[115] buft_net_132 tdr_data_out[115] n2330 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu536 buf_net_424 shift_register[105] buft_net_132 tdr_data_out[105] n2130 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu587 buf_net_424 shift_register[165] buft_net_132 tdr_data_out[165] n333 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu542 buf_net_424 shift_register[109] buft_net_132 tdr_data_out[109] n2210 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu489 buf_net_424 shift_register[36] buft_net_132 tdr_data_out[36] n750 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu537 buf_net_424 shift_register[106] buft_net_132 tdr_data_out[106] n2150 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu555 buf_net_424 shift_register[116] buft_net_132 tdr_data_out[116] n2350 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu559 buf_net_424 shift_register[119] buft_net_132 tdr_data_out[119] n2410 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu516 buf_net_424 shift_register[27] buft_net_132 tdr_data_out[27] n570 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu539 buf_net_424 shift_register[107] buft_net_132 tdr_data_out[107] n2170 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu512 buf_net_424 shift_register[25] buft_net_132 tdr_data_out[25] n530 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu459 buf_net_424 shift_register[26] buft_net_132 tdr_data_out[26] n550 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu671 buf_net_425 data_reg_tdo buft_net_130 tdr_data_out[0] n3 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu597 buf_net_416 shift_register[65] buft_net_135 tdr_data_out[65] n1330 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu589 buf_net_416 shift_register[62] buft_net_135 tdr_data_out[62] n1270 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu603 buf_net_416 shift_register[63] buft_net_135 tdr_data_out[63] n1290 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu591 buf_net_416 shift_register[69] buft_net_135 tdr_data_out[69] n1410 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu596 buf_net_416 shift_register[66] buft_net_135 tdr_data_out[66] n1350 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu599 buf_net_416 shift_register[64] buft_net_135 tdr_data_out[64] n1311 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu595 buf_net_416 shift_register[67] buft_net_135 tdr_data_out[67] n1370 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu646 buf_net_425 shift_register[142] buft_net_130 tdr_data_out[142] n287 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu501 buf_net_417 shift_register[199] buft_net_126 tdr_data_out[199] n401 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu448 buf_net_417 shift_register[138] buft_net_126 tdr_data_out[138] n2791 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu627 buf_net_417 shift_register[204] buft_net_126 tdr_data_out[204] n411 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu629 buf_net_417 shift_register[202] buft_net_126 tdr_data_out[202] n407 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu444 buf_net_417 shift_register[201] buft_net_126 tdr_data_out[201] n405 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu628 buf_net_417 shift_register[206] buft_net_126 tdr_data_out[206] n415 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu505 buf_net_417 shift_register[203] buft_net_126 tdr_data_out[203] n409 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu452 buf_net_417 shift_register[205] buft_net_126 tdr_data_out[205] n413 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu482 buf_net_425 shift_register[2] buft_net_130 tdr_data_out[2] n7 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu520 buf_net_430 shift_register[95] buft_net_122 tdr_data_out[95] n1930 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu668 shift_register[216] buf_net_445 buf_net_436 tdr_data_in[215] n225 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu673 shift_register[208] buf_net_445 buf_net_436 tdr_data_in[207] n217 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu356 shift_register[215] buf_net_445 buf_net_436 tdr_data_in[214] n224 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu665 shift_register[210] buf_net_445 buf_net_436 tdr_data_in[209] n219 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu473 buf_net_430 shift_register[94] buft_net_122 tdr_data_out[94] n1911 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu502 buf_net_430 shift_register[21] buft_net_122 tdr_data_out[21] n4500 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu531 buf_net_430 shift_register[102] buft_net_122 tdr_data_out[102] n2070 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu523 buf_net_430 shift_register[97] buft_net_122 tdr_data_out[97] n1970 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu509 buf_net_430 shift_register[24] buft_net_122 tdr_data_out[24] n510 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu608 buf_net_416 shift_register[58] buft_net_135 tdr_data_out[58] n1190 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu590 buf_net_416 shift_register[70] buft_net_135 tdr_data_out[70] n1430 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu593 buf_net_416 shift_register[68] buft_net_135 tdr_data_out[68] n1390 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu650 buf_net_426 shift_register[141] buft_net_129 tdr_data_out[141] n285 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu604 buf_net_427 shift_register[47] buft_net_124 tdr_data_out[47] n970 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu456 buf_net_426 shift_register[12] buft_net_129 tdr_data_out[12] n2790 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu474 buf_net_427 shift_register[44] buft_net_124 tdr_data_out[44] n910 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu620 buf_net_428 shift_register[46] buft_net_124 tdr_data_out[46] n950 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu572 buf_net_428 shift_register[131] buft_net_124 tdr_data_out[131] n2650 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu540 buf_net_428 shift_register[91] buft_net_124 tdr_data_out[91] n1850 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu583 buf_net_428 shift_register[49] buft_net_124 tdr_data_out[49] n1010 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu484 buf_net_427 shift_register[37] buft_net_124 tdr_data_out[37] n770 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu496 buf_net_428 shift_register[34] buft_net_124 tdr_data_out[34] n710 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu524 buf_net_428 shift_register[93] buft_net_124 tdr_data_out[93] n1890 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu654 buf_net_426 shift_register[11] buft_net_129 tdr_data_out[11] n2510 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu579 buf_net_426 shift_register[75] buft_net_129 tdr_data_out[75] n1530 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu575 buf_net_426 shift_register[77] buft_net_129 tdr_data_out[77] n1570 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu585 buf_net_426 shift_register[72] buft_net_129 tdr_data_out[72] n1470 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu614 buf_net_426 shift_register[52] buft_net_129 tdr_data_out[52] n1070 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu582 buf_net_426 shift_register[73] buft_net_129 tdr_data_out[73] n1490 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu586 buf_net_426 shift_register[71] buft_net_129 tdr_data_out[71] n1450 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu581 buf_net_426 shift_register[74] buft_net_129 tdr_data_out[74] n1511 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu577 buf_net_426 shift_register[76] buft_net_129 tdr_data_out[76] n1550 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu652 buf_net_427 shift_register[140] buft_net_124 tdr_data_out[140] n283 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu618 buf_net_427 shift_register[42] buft_net_124 tdr_data_out[42] n870 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu613 buf_net_427 shift_register[41] buft_net_124 tdr_data_out[41] n850 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu619 buf_net_427 shift_register[38] buft_net_124 tdr_data_out[38] n790 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu598 buf_net_427 shift_register[39] buft_net_124 tdr_data_out[39] n810 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu480 buf_net_427 shift_register[43] buft_net_124 tdr_data_out[43] n890 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu602 buf_net_427 shift_register[48] buft_net_124 tdr_data_out[48] n990 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu653 buf_net_427 shift_register[139] buft_net_124 tdr_data_out[139] n281 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu519 buf_net_428 shift_register[100] buft_net_124 tdr_data_out[100] n2030 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu470 buf_net_428 shift_register[51] buft_net_124 tdr_data_out[51] n1050 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu532 buf_net_428 shift_register[92] buft_net_124 tdr_data_out[92] n1870 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu617 buf_net_428 shift_register[45] buft_net_124 tdr_data_out[45] n930 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu543 buf_net_428 shift_register[90] buft_net_124 tdr_data_out[90] n1830 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu547 buf_net_428 shift_register[89] buft_net_124 tdr_data_out[89] n1810 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu554 buf_net_427 shift_register[87] buft_net_124 tdr_data_out[87] n1770 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu551 buf_net_427 shift_register[88] buft_net_124 tdr_data_out[88] n1790 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu342 shift_register[219] buf_net_445 buf_net_436 tdr_data_in[218] n228 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu669 shift_register[220] buf_net_445 buf_net_436 tdr_data_in[219] n229 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu357 shift_register[217] buf_net_445 buf_net_436 tdr_data_in[216] n226 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu670 shift_register[214] buf_net_445 buf_net_436 tdr_data_in[213] n223 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu664 shift_register[222] buf_net_445 buf_net_436 tdr_data_in[221] n231 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu647 buf_net_419 shift_register[158] buft_net_126 tdr_data_out[158] n319 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu638 buf_net_419 shift_register[159] buft_net_126 tdr_data_out[159] n321 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu662 shift_register[213] buf_net_445 buf_net_436 tdr_data_in[212] n222 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu661 shift_register[211] buf_net_445 buf_net_436 tdr_data_in[210] n220 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu517 buf_net_419 shift_register[161] buft_net_126 tdr_data_out[161] n325 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu451 buf_net_419 shift_register[134] buft_net_126 tdr_data_out[134] n2710 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu453 buf_net_419 shift_register[163] buft_net_126 tdr_data_out[163] n329 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu440 buf_net_419 shift_register[133] buft_net_126 tdr_data_out[133] n2690 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu640 buf_net_419 shift_register[160] buft_net_126 tdr_data_out[160] n323 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu626 buf_net_419 shift_register[137] buft_net_126 tdr_data_out[137] n2770 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu634 buf_net_419 shift_register[136] buft_net_126 tdr_data_out[136] n2750 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu633 buf_net_419 shift_register[135] buft_net_126 tdr_data_out[135] n2730 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu632 buf_net_419 shift_register[162] buft_net_126 tdr_data_out[162] n327 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu645 buf_net_419 shift_register[157] buft_net_126 tdr_data_out[157] n317 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu639 buf_net_419 shift_register[156] buft_net_126 tdr_data_out[156] n315 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu347 buf_net_419 shift_register[164] buft_net_126 tdr_data_out[164] n331 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu576 buf_net_418 shift_register[176] buft_net_128 tdr_data_out[176] n355 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu610 buf_net_418 shift_register[179] buft_net_128 tdr_data_out[179] n361 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu528 buf_net_418 shift_register[173] buft_net_128 tdr_data_out[173] n349 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu588 buf_net_418 shift_register[180] buft_net_128 tdr_data_out[180] n363 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu549 buf_net_418 shift_register[175] buft_net_128 tdr_data_out[175] n353 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu584 buf_net_418 shift_register[177] buft_net_128 tdr_data_out[177] n357 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu530 buf_net_421 shift_register[169] buft_net_125 tdr_data_out[169] n341 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu611 buf_net_418 shift_register[184] buft_net_125 tdr_data_out[184] n371 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu600 buf_net_421 shift_register[183] buft_net_125 tdr_data_out[183] n369 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu433 buf_net_421 shift_register[185] buft_net_125 tdr_data_out[185] n373 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu441 buf_net_421 shift_register[188] buft_net_125 tdr_data_out[188] n379 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu432 buf_net_421 shift_register[187] buft_net_125 tdr_data_out[187] n377 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu465 buf_net_420 shift_register[191] buft_net_123 tdr_data_out[191] n385 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu439 buf_net_420 shift_register[193] buft_net_123 tdr_data_out[193] n389 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu494 buf_net_420 shift_register[198] buft_net_123 tdr_data_out[198] n399 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu449 buf_net_420 shift_register[195] buft_net_123 tdr_data_out[195] n393 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu648 buf_net_423 shift_register[155] buft_net_127 tdr_data_out[155] n313 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu462 buf_net_423 shift_register[78] buft_net_127 tdr_data_out[78] n1590 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu442 buf_net_423 shift_register[83] buft_net_127 tdr_data_out[83] n1690 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu460 buf_net_423 shift_register[85] buft_net_127 tdr_data_out[85] n1730 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu569 buf_net_422 shift_register[125] buft_net_133 tdr_data_out[125] n2530 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu479 buf_net_422 shift_register[130] buft_net_133 tdr_data_out[130] n2630 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu565 buf_net_422 shift_register[122] buft_net_133 tdr_data_out[122] n2470 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu568 buf_net_422 shift_register[124] buft_net_133 tdr_data_out[124] n2511 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu492 buf_net_422 shift_register[35] buft_net_133 tdr_data_out[35] n730 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu556 buf_net_422 shift_register[117] buft_net_133 tdr_data_out[117] n2370 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu630 buf_net_425 shift_register[151] buft_net_131 tdr_data_out[151] n305 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu624 buf_net_425 shift_register[149] buft_net_131 tdr_data_out[149] n301 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu594 buf_net_421 shift_register[181] buft_net_125 tdr_data_out[181] n365 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu535 buf_net_418 shift_register[174] buft_net_128 tdr_data_out[174] n351 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu515 buf_net_418 shift_register[171] buft_net_128 tdr_data_out[171] n345 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu573 buf_net_418 shift_register[170] buft_net_128 tdr_data_out[170] n343 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu443 buf_net_421 shift_register[186] buft_net_125 tdr_data_out[186] n375 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu621 buf_net_421 shift_register[182] buft_net_125 tdr_data_out[182] n367 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu592 buf_net_418 shift_register[178] buft_net_128 tdr_data_out[178] n359 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu522 buf_net_418 shift_register[172] buft_net_128 tdr_data_out[172] n347 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu352 buf_net_420 shift_register[200] buft_net_123 tdr_data_out[200] n403 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu486 buf_net_420 shift_register[197] buft_net_123 tdr_data_out[197] n397 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu447 buf_net_420 shift_register[192] buft_net_123 tdr_data_out[192] n387 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu450 buf_net_420 shift_register[190] buft_net_123 tdr_data_out[190] n383 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu478 buf_net_420 shift_register[196] buft_net_123 tdr_data_out[196] n395 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu655 buf_net_423 shift_register[10] buft_net_127 tdr_data_out[10] n2310 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu616 buf_net_423 shift_register[40] buft_net_127 tdr_data_out[40] n830 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu570 buf_net_423 shift_register[79] buft_net_127 tdr_data_out[79] n1610 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu635 buf_net_423 shift_register[153] buft_net_127 tdr_data_out[153] n309 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu651 buf_net_423 shift_register[154] buft_net_127 tdr_data_out[154] n311 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu557 buf_net_423 shift_register[86] buft_net_127 tdr_data_out[86] n1750 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu564 buf_net_423 shift_register[81] buft_net_127 tdr_data_out[81] n1650 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu567 buf_net_423 shift_register[80] buft_net_127 tdr_data_out[80] n1630 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu438 buf_net_423 shift_register[84] buft_net_127 tdr_data_out[84] n1711 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu560 buf_net_423 shift_register[82] buft_net_127 tdr_data_out[82] n1670 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu571 buf_net_422 shift_register[126] buft_net_133 tdr_data_out[126] n2550 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu563 buf_net_422 shift_register[121] buft_net_133 tdr_data_out[121] n2450 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu558 buf_net_422 shift_register[118] buft_net_133 tdr_data_out[118] n2390 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu561 buf_net_422 shift_register[120] buft_net_133 tdr_data_out[120] n2430 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu566 buf_net_422 shift_register[123] buft_net_133 tdr_data_out[123] n2490 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu641 buf_net_425 shift_register[146] buft_net_131 tdr_data_out[146] n295 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu643 buf_net_425 shift_register[147] buft_net_131 tdr_data_out[147] n297 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu642 buf_net_425 shift_register[143] buft_net_131 tdr_data_out[143] n289 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu644 buf_net_425 shift_register[144] buft_net_131 tdr_data_out[144] n291 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu497 buf_net_430 shift_register[18] buft_net_122 tdr_data_out[18] n390 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu637 buf_net_425 shift_register[148] buft_net_130 tdr_data_out[148] n299 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu481 buf_net_425 shift_register[1] buft_net_130 tdr_data_out[1] n5 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu636 buf_net_425 shift_register[4] buft_net_130 tdr_data_out[4] n11 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu485 buf_net_425 shift_register[3] buft_net_130 tdr_data_out[3] n9 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu606 buf_net_416 shift_register[60] buft_net_135 tdr_data_out[60] n1230 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu488 buf_net_416 shift_register[13] buft_net_135 tdr_data_out[13] n2900 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu605 buf_net_416 shift_register[61] buft_net_135 tdr_data_out[61] n1250 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu601 buf_net_416 shift_register[59] buft_net_135 tdr_data_out[59] n1210 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu660 buf_net_425 shift_register[5] buft_net_130 tdr_data_out[5] n1310 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu656 buf_net_425 shift_register[9] buft_net_130 tdr_data_out[9] n2110 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu649 buf_net_425 shift_register[145] buft_net_130 tdr_data_out[145] n293 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu504 buf_net_430 shift_register[22] buft_net_134 tdr_data_out[22] n470 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu491 buf_net_430 shift_register[15] buft_net_134 tdr_data_out[15] n330 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu498 buf_net_430 shift_register[19] buft_net_134 tdr_data_out[19] n4100 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu493 buf_net_416 shift_register[16] buft_net_134 tdr_data_out[16] n3500 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu663 shift_register[221] buf_net_445 buf_net_436 tdr_data_in[220] n230 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xu672 shift_register[209] buf_net_445 buf_net_436 tdr_data_in[208] n218 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_70 eco_net_5_0 shift_register[71] tdr_data_in[70] eco_net_1_0 n80 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_146 eco_net_4_0 shift_register[98] tdr_data_in[97] eco_net_0 n107 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_38 eco_net_6_0 shift_register[117] tdr_data_in[116] eco_net_2_0 n126 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_172 eco_net_3_0 shift_register[10] tdr_data_in[9] eco_net n19 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_165 eco_net_3_0 shift_register[144] tdr_data_in[143] eco_net n153 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_173 eco_net_3_0 shift_register[103] tdr_data_in[102] eco_net n112 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_190 eco_net_3_0 shift_register[53] tdr_data_in[52] eco_net n62 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_131 eco_net_4_0 shift_register[21] tdr_data_in[20] eco_net_0 n30 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_90 eco_net_5_0 shift_register[54] tdr_data_in[53] eco_net_1_0 n63 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_118 eco_net_4_0 shift_register[13] tdr_data_in[12] eco_net_0 n22 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_202 eco_net_3_0 shift_register[97] tdr_data_in[96] eco_net n106 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_17 eco_net_6_0 shift_register[18] tdr_data_in[17] eco_net_2_0 n27 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_55 eco_net_5_0 shift_register[148] tdr_data_in[147] eco_net_1_0 n157 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_123 eco_net_4_0 shift_register[17] tdr_data_in[16] eco_net_0 n26 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_52 eco_net_6_0 shift_register[61] tdr_data_in[60] eco_net_2_0 n70 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_178 eco_net_3_0 shift_register[32] tdr_data_in[31] eco_net n41 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_167 eco_net_3_0 shift_register[102] tdr_data_in[101] eco_net n111 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_191 eco_net_3_0 shift_register[75] tdr_data_in[74] eco_net n84 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_122 eco_net_4_0 shift_register[120] tdr_data_in[119] eco_net_0 n129 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_117 eco_net_4_0 shift_register[133] eco_net_0 tdr_data_in[132] n142 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_207 eco_net_3_0 shift_register[85] tdr_data_in[84] eco_net n94 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_8 eco_net_6_0 shift_register[88] tdr_data_in[87] eco_net_2_0 n97 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_130 eco_net_4_0 shift_register[89] tdr_data_in[88] eco_net_0 n98 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_204 eco_net_3_0 shift_register[87] tdr_data_in[86] eco_net n96 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_73 eco_net_5_0 shift_register[157] tdr_data_in[156] eco_net_1_0 n166 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_36 eco_net_6_0 shift_register[90] tdr_data_in[89] eco_net_2_0 n99 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_112 eco_net_4_0 shift_register[155] tdr_data_in[154] eco_net_0 n164 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_10 eco_net_6_0 shift_register[82] tdr_data_in[81] eco_net_2_0 n91 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_206 eco_net_3_0 shift_register[86] tdr_data_in[85] eco_net n95 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_164 eco_net_3_0 shift_register[92] tdr_data_in[91] eco_net n101 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_33 eco_net_6_0 shift_register[91] tdr_data_in[90] eco_net_2_0 n100 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_9 eco_net_6_0 shift_register[158] tdr_data_in[157] eco_net_2_0 n167 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_62 eco_net_5_0 shift_register[159] tdr_data_in[158] eco_net_1_0 n168 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_23 eco_net_6_0 shift_register[160] tdr_data_in[159] eco_net_2_0 n169 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_186 eco_net_3_0 shift_register[131] tdr_data_in[130] eco_net n140 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_67 eco_net_5_0 shift_register[135] tdr_data_in[134] eco_net_1_0 n144 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_50 eco_net_6_0 shift_register[134] tdr_data_in[133] eco_net_2_0 n143 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_200 eco_net_3_0 shift_register[202] tdr_data_in[201] eco_net n211 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_75 eco_net_5_0 shift_register[156] tdr_data_in[155] eco_net_1_0 n165 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_177 eco_net_3_0 shift_register[132] tdr_data_in[131] eco_net n141 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_194 eco_net_3_0 shift_register[205] tdr_data_in[204] eco_net n214 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_193 eco_net_3_0 shift_register[204] tdr_data_in[203] eco_net n213 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_205 eco_net_3_0 shift_register[73] tdr_data_in[72] eco_net n82 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_188 eco_net_3_0 shift_register[169] tdr_data_in[168] eco_net n178 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_65 eco_net_5_0 shift_register[181] tdr_data_in[180] eco_net_1_0 n190 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_129 eco_net_4_0 shift_register[59] tdr_data_in[58] eco_net_0 n68 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_184 eco_net_3_0 shift_register[190] tdr_data_in[189] eco_net n199 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_27 eco_net_6_0 shift_register[189] tdr_data_in[188] eco_net_2_0 n198 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_96 eco_net_5_0 shift_register[176] tdr_data_in[175] eco_net_1_0 n185 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_183 eco_net_3_0 shift_register[109] tdr_data_in[108] eco_net n118 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_182 eco_net_3_0 shift_register[164] tdr_data_in[163] eco_net n173 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_180 eco_net_3_0 shift_register[139] tdr_data_in[138] eco_net n148 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_80 eco_net_5_0 shift_register[127] tdr_data_in[126] eco_net_1_0 n136 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_30 eco_net_6_0 shift_register[129] tdr_data_in[128] eco_net_2_0 n138 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_195 eco_net_3_0 shift_register[196] tdr_data_in[195] eco_net n205 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_203 eco_net_3_0 shift_register[84] tdr_data_in[83] eco_net n93 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_201 eco_net_3_0 shift_register[81] tdr_data_in[80] eco_net n90 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_198 eco_net_3_0 shift_register[83] tdr_data_in[82] eco_net n92 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_197 eco_net_3_0 shift_register[68] tdr_data_in[67] eco_net n77 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_124 eco_net_4_0 shift_register[66] tdr_data_in[65] eco_net_0 n75 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_79 eco_net_5_0 shift_register[65] tdr_data_in[64] eco_net_1_0 n74 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_196 eco_net_3_0 shift_register[45] tdr_data_in[44] eco_net n54 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_192 eco_net_3_0 shift_register[108] tdr_data_in[107] eco_net n117 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_125 eco_net_4_0 shift_register[27] tdr_data_in[26] eco_net_0 n36 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_53 eco_net_6_0 shift_register[107] tdr_data_in[106] eco_net_2_0 n116 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_189 eco_net_3_0 shift_register[177] tdr_data_in[176] eco_net n186 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_92 eco_net_5_0 shift_register[184] tdr_data_in[183] eco_net_1_0 n193 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_71 eco_net_5_0 shift_register[178] tdr_data_in[177] eco_net_1_0 n187 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_68 eco_net_5_0 shift_register[174] tdr_data_in[173] eco_net_1_0 n183 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_187 eco_net_3_0 shift_register[44] tdr_data_in[43] eco_net n53 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_185 eco_net_3_0 shift_register[19] tdr_data_in[18] eco_net n28 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_154 eco_net_4_0 shift_register[60] tdr_data_in[59] eco_net_0 n69 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_15 eco_net_6_0 shift_register[62] tdr_data_in[61] eco_net_2_0 n71 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_34 eco_net_6_0 shift_register[58] tdr_data_in[57] eco_net_2_0 n67 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_32 eco_net_6_0 shift_register[172] tdr_data_in[171] eco_net_2_0 n181 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_103 eco_net_5_0 shift_register[180] tdr_data_in[179] eco_net_1_0 n189 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_93 eco_net_5_0 shift_register[182] tdr_data_in[181] eco_net_1_0 n191 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_77 eco_net_5_0 shift_register[118] tdr_data_in[117] eco_net_1_0 n127 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_41 eco_net_6_0 shift_register[36] tdr_data_in[35] eco_net_2_0 n45 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_139 eco_net_4_0 shift_register[34] tdr_data_in[33] eco_net_0 n43 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_97 eco_net_5_0 shift_register[128] tdr_data_in[127] eco_net_1_0 n137 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xu506 buf_net_429 shift_register[23] buft_net_134 tdr_data_out[23] n4900 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_66 eco_net_5_0 shift_register[112] tdr_data_in[111] eco_net_1_0 n121 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_179 eco_net_3_0 shift_register[192] tdr_data_in[191] eco_net n201 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_143 eco_net_4_0 shift_register[193] tdr_data_in[192] eco_net_0 n202 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_174 eco_net_3_0 shift_register[173] tdr_data_in[172] eco_net n182 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_168 eco_net_3_0 shift_register[175] tdr_data_in[174] eco_net n184 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_116 eco_net_4_0 shift_register[57] tdr_data_in[56] eco_net_0 n66 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_169 eco_net_3_0 shift_register[170] tdr_data_in[169] eco_net n179 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_102 eco_net_5_0 shift_register[171] tdr_data_in[170] eco_net_1_0 n180 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_166 eco_net_3_0 shift_register[141] tdr_data_in[140] eco_net n150 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_141 eco_net_4_0 shift_register[40] tdr_data_in[39] eco_net_0 n49 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_45 eco_net_6_0 shift_register[20] tdr_data_in[19] eco_net_2_0 n29 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_181 eco_net_3_0 shift_register[51] tdr_data_in[50] eco_net n60 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_161 eco_net_3_0 shift_register[35] tdr_data_in[34] eco_net n44 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_176 eco_net_3_0 shift_register[179] tdr_data_in[178] eco_net n188 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_58 eco_net_5_0 shift_register[185] tdr_data_in[184] eco_net_1_0 n194 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_175 eco_net_3_0 shift_register[201] tdr_data_in[200] eco_net n210 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_171 eco_net_3_0 shift_register[56] tdr_data_in[55] eco_net n65 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_95 eco_net_5_0 shift_register[55] tdr_data_in[54] eco_net_1_0 n64 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_84 eco_net_5_0 shift_register[76] tdr_data_in[75] eco_net_1_0 n85 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_170 eco_net_3_0 shift_register[79] tdr_data_in[78] eco_net n88 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_91 eco_net_5_0 shift_register[39] tdr_data_in[38] eco_net_1_0 n48 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_40 eco_net_6_0 shift_register[42] tdr_data_in[41] eco_net_2_0 n51 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_7 eco_net_6_0 shift_register[43] tdr_data_in[42] eco_net_2_0 n52 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_163 eco_net_3_0 shift_register[114] tdr_data_in[113] eco_net n123 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_155 eco_net_4_0 shift_register[100] tdr_data_in[99] eco_net_0 n109 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_148 eco_net_4_0 shift_register[113] tdr_data_in[112] eco_net_0 n122 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_162 eco_net_3_0 shift_register[14] tdr_data_in[13] eco_net n23 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_109 eco_net_4_0 shift_register[15] tdr_data_in[14] eco_net_0 n24 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_83 eco_net_5_0 shift_register[16] tdr_data_in[15] eco_net_1_0 n25 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_2 eco_net_6_0 shift_register[37] tdr_data_in[36] eco_net_2_0 n46 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_153 eco_net_4_0 shift_register[105] tdr_data_in[104] eco_net_0 n114 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_42 eco_net_6_0 shift_register[101] tdr_data_in[100] eco_net_2_0 n110 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_159 eco_net_3_0 shift_register[115] tdr_data_in[114] eco_net n124 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_160 eco_net_3_0 shift_register[152] tdr_data_in[151] eco_net n161 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_39 eco_net_6_0 shift_register[104] tdr_data_in[103] eco_net_2_0 n113 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_29 eco_net_6_0 shift_register[119] tdr_data_in[118] eco_net_2_0 n128 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_44 eco_net_6_0 shift_register[165] tdr_data_in[164] eco_net_2_0 n174 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_105 eco_net_5_0 shift_register[167] tdr_data_in[166] eco_net_1_0 n176 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_156 eco_net_4_0 shift_register[31] tdr_data_in[30] eco_net_0 n40 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_87 eco_net_5_0 shift_register[30] tdr_data_in[29] eco_net_1_0 n39 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_121 eco_net_4_0 shift_register[25] tdr_data_in[24] eco_net_0 n34 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_94 eco_net_5_0 shift_register[29] tdr_data_in[28] eco_net_1_0 n38 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_133 eco_net_4_0 shift_register[33] tdr_data_in[32] eco_net_0 n42 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_99 eco_net_5_0 shift_register[168] tdr_data_in[167] eco_net_1_0 n177 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_28 eco_net_6_0 shift_register[121] tdr_data_in[120] eco_net_2_0 n130 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_152 eco_net_4_0 shift_register[116] tdr_data_in[115] eco_net_0 n125 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_16 eco_net_6_0 shift_register[111] tdr_data_in[110] eco_net_2_0 n120 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_120 eco_net_4_0 shift_register[26] tdr_data_in[25] eco_net_0 n35 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_56 eco_net_5_0 shift_register[110] tdr_data_in[109] eco_net_1_0 n119 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_147 eco_net_4_0 shift_register[28] tdr_data_in[27] eco_net_0 n37 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_85 eco_net_5_0 shift_register[106] tdr_data_in[105] eco_net_1_0 n115 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xu580 buf_net_424 shift_register[166] buft_net_132 tdr_data_out[166] n335 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_51 eco_net_6_0 shift_register[166] tdr_data_in[165] eco_net_2_0 n175 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_61 eco_net_5_0 shift_register[122] tdr_data_in[121] eco_net_1_0 n131 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_6 eco_net_6_0 shift_register[125] tdr_data_in[124] eco_net_2_0 n134 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_108 eco_net_4_0 shift_register[123] tdr_data_in[122] eco_net_0 n132 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_135 eco_net_4_0 shift_register[151] tdr_data_in[150] eco_net_0 n160 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_88 eco_net_5_0 shift_register[147] tdr_data_in[146] eco_net_1_0 n156 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_72 eco_net_5_0 shift_register[9] tdr_data_in[8] eco_net_1_0 n18 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_69 eco_net_5_0 shift_register[8] tdr_data_in[7] eco_net_1_0 n17 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_134 eco_net_4_0 shift_register[1] tdr_data_in[0] eco_net_0 n8 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_145 eco_net_4_0 shift_register[23] tdr_data_in[22] eco_net_0 n32 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_150 eco_net_4_0 shift_register[195] tdr_data_in[194] eco_net_0 n204 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_98 eco_net_5_0 shift_register[63] tdr_data_in[62] eco_net_1_0 n72 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_138 eco_net_4_0 shift_register[74] tdr_data_in[73] eco_net_0 n83 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_136 eco_net_4_0 shift_register[77] tdr_data_in[76] eco_net_0 n86 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_137 eco_net_4_0 shift_register[163] tdr_data_in[162] eco_net_0 n172 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_24 eco_net_6_0 shift_register[138] tdr_data_in[137] eco_net_2_0 n147 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_86 eco_net_5_0 shift_register[2] tdr_data_in[1] eco_net_1_0 n10 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_151 eco_net_4_0 shift_register[24] tdr_data_in[23] eco_net_0 n33 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_25 eco_net_6_0 shift_register[22] tdr_data_in[21] eco_net_2_0 n31 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_100 eco_net_5_0 shift_register[99] tdr_data_in[98] eco_net_1_0 n108 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_76 eco_net_5_0 shift_register[96] tdr_data_in[95] eco_net_1_0 n105 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_5 eco_net_6_0 shift_register[95] tdr_data_in[94] eco_net_2_0 n104 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_114 eco_net_4_0 shift_register[199] tdr_data_in[198] eco_net_0 n208 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_63 eco_net_5_0 shift_register[198] tdr_data_in[197] eco_net_1_0 n207 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_149 eco_net_4_0 shift_register[207] eco_net_0 tdr_data_in[206] n216 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_47 eco_net_6_0 shift_register[200] tdr_data_in[199] eco_net_2_0 n209 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_140 eco_net_4_0 shift_register[206] eco_net_0 tdr_data_in[205] n215 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_46 eco_net_6_0 shift_register[162] tdr_data_in[161] eco_net_2_0 n171 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_144 eco_net_4_0 shift_register[64] tdr_data_in[63] eco_net_0 n73 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_64 eco_net_5_0 shift_register[67] tdr_data_in[66] eco_net_1_0 n76 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_142 eco_net_4_0 shift_register[3] tdr_data_in[2] eco_net_0 n12 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_82 eco_net_5_0 shift_register[69] tdr_data_in[68] eco_net_1_0 n78 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_128 eco_net_4_0 shift_register[70] tdr_data_in[69] eco_net_0 n79 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_74 eco_net_5_0 shift_register[72] tdr_data_in[71] eco_net_1_0 n81 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_126 eco_net_4_0 shift_register[149] tdr_data_in[148] eco_net_0 n158 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_37 eco_net_6_0 shift_register[150] tdr_data_in[149] eco_net_2_0 n159 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_132 eco_net_4_0 shift_register[4] tdr_data_in[3] eco_net_0 n13 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_1 eco_net_6_0 shift_register[5] tdr_data_in[4] eco_net_2_0 n14 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_119 eco_net_4_0 shift_register[130] tdr_data_in[129] eco_net_0 n139 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_158 eco_net_3_0 shift_register[38] tdr_data_in[37] eco_net n47 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_157 eco_net_3_0 shift_register[142] tdr_data_in[141] eco_net n151 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_110 eco_net_4_0 shift_register[52] eco_net_0 tdr_data_in[51] n61 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_106 eco_net_4_0 shift_register[136] tdr_data_in[135] eco_net_0 n145 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_107 eco_net_4_0 shift_register[11] tdr_data_in[10] eco_net_0 n20 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_31 eco_net_6_0 shift_register[153] tdr_data_in[152] eco_net_2_0 n162 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_49 eco_net_6_0 shift_register[137] tdr_data_in[136] eco_net_2_0 n146 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_127 eco_net_4_0 shift_register[6] tdr_data_in[5] eco_net_0 n15 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_78 eco_net_5_0 shift_register[126] tdr_data_in[125] eco_net_1_0 n135 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_14 eco_net_6_0 shift_register[124] tdr_data_in[123] eco_net_2_0 n133 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_115 eco_net_4_0 shift_register[49] tdr_data_in[48] eco_net_0 n58 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_101 eco_net_5_0 shift_register[78] tdr_data_in[77] eco_net_1_0 n87 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_11 eco_net_6_0 shift_register[48] tdr_data_in[47] eco_net_2_0 n57 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_113 eco_net_4_0 shift_register[187] tdr_data_in[186] eco_net_0 n196 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_54 eco_net_6_0 shift_register[183] tdr_data_in[182] eco_net_2_0 n192 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_21 eco_net_6_0 shift_register[188] tdr_data_in[187] eco_net_2_0 n197 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_19 eco_net_6_0 shift_register[186] tdr_data_in[185] eco_net_2_0 n195 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_111 eco_net_4_0 shift_register[191] tdr_data_in[190] eco_net_0 n200 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_60 eco_net_5_0 shift_register[197] tdr_data_in[196] eco_net_1_0 n206 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_20 eco_net_6_0 shift_register[194] tdr_data_in[193] eco_net_2_0 n203 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xu527 buf_net_430 shift_register[99] buft_net_122 tdr_data_out[99] n2010 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_104 eco_net_5_0 shift_register[203] tdr_data_in[202] eco_net_1_0 n212 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_26 eco_net_6_0 shift_register[161] tdr_data_in[160] eco_net_2_0 n170 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_81 eco_net_5_0 shift_register[154] tdr_data_in[153] eco_net_1_0 n163 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_13 eco_net_6_0 shift_register[7] tdr_data_in[6] eco_net_2_0 n16 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_89 eco_net_5_0 shift_register[145] tdr_data_in[144] eco_net_1_0 n154 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_4 eco_net_6_0 shift_register[146] tdr_data_in[145] eco_net_2_0 n155 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_57 eco_net_5_0 shift_register[143] tdr_data_in[142] eco_net_1_0 n152 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_59 eco_net_5_0 shift_register[140] tdr_data_in[139] eco_net_1_0 n149 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_22 eco_net_6_0 shift_register[41] tdr_data_in[40] eco_net_2_0 n50 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_48 eco_net_6_0 shift_register[94] tdr_data_in[93] eco_net_2_0 n103 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_3 eco_net_6_0 shift_register[12] tdr_data_in[11] eco_net_2_0 n21 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_43 eco_net_6_0 shift_register[93] tdr_data_in[92] eco_net_2_0 n102 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_18 eco_net_6_0 shift_register[46] tdr_data_in[45] eco_net_2_0 n55 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_35 eco_net_6_0 shift_register[50] tdr_data_in[49] eco_net_2_0 n59 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xins_eco_12 eco_net_6_0 shift_register[47] tdr_data_in[46] eco_net_2_0 n56 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xu666 shift_register[218] buf_net_445 buf_net_436 tdr_data_in[217] n227 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xu667 shift_register[212] buf_net_445 buf_net_436 tdr_data_in[211] n221 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xu464 buf_net_420 shift_register[194] buft_net_123 tdr_data_out[194] n391 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xu525 buf_net_430 shift_register[98] buft_net_122 tdr_data_out[98] n1990 vdd vssx ringpll__b15ao0022an1n02x5 m=1
Xplace_rlb__599 buf_net_393 p_abuf11 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_466 aps_rename_1433 buf_net_396 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_ainv_p_459 buf_net_393 p_abuf70 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_161 p_abuf70 tdr_data_out[132] vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_157 p_abuf10 p_abuf2 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_rlb__597 buf_net_393 p_abuf13 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_159 p_abuf13 p_abuf0 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_ainv_p_453 buf_net_393 p_abuf8 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_155 p_abuf8 p_abuf3 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_ainv_p_451 buf_net_393 p_abuf14 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_464 buf_net_396 p_abuf15 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_ainv_p_499 net_net_569 buf_net_429 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_ainv_p_489 net_net_569 buf_net_419 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_108 ropt_net_571 buft_net_108 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_ainv_p_506 buf_net_441 buf_net_436 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_ainv_p_498 net_net_569 buf_net_428 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_465 buf_net_396 p_abuf71 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_117 ropt_net_571 buft_net_117 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_121 ropt_net_571 buft_net_121 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_120 ropt_net_571 buft_net_120 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_97 ropt_net_571 buft_net_97 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_93 ropt_net_571 buft_net_93 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_91 ropt_net_571 buft_net_91 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_123 buf_net_420 buft_net_123 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_binv_r_133 buf_net_422 buft_net_133 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_125 buf_net_421 buft_net_125 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_127 buf_net_423 buft_net_127 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_rlb__601 buf_net_393 p_abuf7 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_153 p_abuf15 tdr_data_out[189] vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_526 buf_net_463 buf_net_456 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_510 buf_net_441 buf_net_440 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_134 buf_net_430 buft_net_134 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_130 buf_net_425 buft_net_130 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_131 buf_net_425 buft_net_131 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_118 ropt_net_571 buft_net_118 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_114 ropt_net_571 buft_net_114 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_113 ropt_net_571 buft_net_113 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_103 ropt_net_571 buft_net_103 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xins_eco_215 n4 net_eco_5 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xins_eco_213 n811 net_eco_3 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_100 n468 buft_net_100 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_98 ropt_net_571 buft_net_98 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_95 n468 buft_net_95 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_129 buf_net_426 buft_net_129 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_128 buf_net_418 buft_net_128 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xu815 n230 net46 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1046 net46 net480 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu748 net391 net182 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu870 net182 net304 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu957 net480 net391 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu895 net304 net329 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1036 net537 net470 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu947 net470 net381 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1103 n218 net537 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu860 net176 net294 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu861 net294 net295 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu742 net381 net176 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu894 net198 net328 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu764 net400 net198 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu966 net490 net400 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu827 n107 net58 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1056 net58 net490 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu944 net205 net378 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu771 net467 net205 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1097 n153 net531 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1033 net531 net467 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu803 n112 net237 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu936 net203 net370 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu769 net461 net203 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu798 n62 net232 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu998 net232 net432 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1091 n30 net525 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1027 net525 net461 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu808 n63 net242 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu889 net195 net323 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu761 net382 net195 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu948 net469 net382 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1099 n22 net533 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1035 net533 net469 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu813 n106 net247 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu980 net216 net414 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu840 net414 net71 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu782 n232 net216 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu790 n270 net224 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu987 net224 net421 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu788 n234 net222 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu986 net222 net420 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu802 n101 net236 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu984 net221 net418 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu787 n253 net221 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu784 net1 net218 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu981 net218 net415 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1 n254 net1 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu800 n167 net234 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1000 net234 net434 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu969 net336 net403 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu902 net493 net336 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1059 net70 net493 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu766 n273 net200 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu839 net200 net70 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu793 n235 net227 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu979 net215 net413 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu991 net227 net425 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu794 n233 net228 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu974 net211 net408 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu992 net228 net426 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1070 n168 net504 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu781 net504 net215 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1065 n169 net499 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu777 net499 net211 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu810 n140 net244 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1022 net365 net456 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu931 net517 net365 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu767 n238 net201 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1083 net201 net517 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu801 n247 net235 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1001 net235 net435 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu812 n274 net246 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu809 n249 net243 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1094 n82 net528 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu770 net465 net204 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu938 net204 net372 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1031 net528 net465 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu785 n178 net219 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu983 net219 net417 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu982 net217 net416 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu838 n190 net69 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu783 net69 net217 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu807 n68 net241 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu795 n185 net229 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu993 net229 net427 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1100 n118 net534 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1038 net534 net472 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu950 net472 net384 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu858 net175 net292 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu859 net292 net293 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu739 net384 net175 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu806 n173 net240 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu965 net208 net399 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu774 net489 net208 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu3 n148 net3 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1055 net3 net489 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu805 n136 net239 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu956 net206 net390 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu772 net478 net206 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu828 n138 net59 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1044 net59 net478 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu791 n271 net225 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu989 net225 net423 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu869 net181 net303 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu747 net401 net181 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu967 net491 net401 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu893 net303 net327 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu823 n121 net54 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1057 net54 net491 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu792 n182 net226 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu990 net226 net424 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu789 n184 net223 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu985 net223 net419 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu977 net214 net411 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1069 n66 net503 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu780 net503 net214 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu796 n150 net230 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu994 net230 net428 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu976 net213 net410 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1067 n49 net501 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu779 net501 net213 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu988 net220 net422 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu5 n29 net4 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu786 net4 net220 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu797 n114 net231 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu995 net231 net429 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu757 net368 net191 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu934 net460 net368 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1026 net524 net460 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu882 net191 net316 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu833 n110 net64 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1090 net64 net524 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu863 net296 net297 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu862 net177 net296 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu953 net474 net387 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1040 net45 net474 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu315 n124 net45 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu743 net387 net177 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu853 net286 net287 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu738 net373 net174 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu939 net464 net373 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1030 net527 net464 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu852 net174 net286 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu830 n128 net61 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1093 net61 net527 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu955 net207 net389 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu773 net476 net207 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu832 n176 net63 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1042 net63 net476 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu892 net197 net326 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu763 net395 net197 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu961 net484 net395 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu825 n32 net56 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1050 net56 net484 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu837 n204 net68 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1092 net68 net526 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1029 net526 net463 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu759 net374 net193 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu884 net193 net318 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu940 net463 net374 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu811 n172 net245 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu901 net199 net335 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu765 net406 net199 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu972 net496 net406 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu836 n10 net67 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1062 net67 net496 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu2 n139 net2 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1088 net2 net522 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu768 net457 net202 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu932 net202 net366 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1023 net522 net457 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu814 n47 net248 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1064 n61 net498 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu776 net498 net210 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu973 net210 net407 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1066 n145 net500 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu975 net212 net409 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu778 net500 net212 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu799 n146 net233 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu999 net233 net433 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu755 net362 net189 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu928 net452 net362 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1018 net516 net452 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu880 net189 net314 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu829 n225 net60 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1082 net60 net516 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu874 net186 net308 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu752 net397 net186 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu963 net487 net397 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu899 net308 net333 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu820 n217 net51 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1053 net51 net487 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1081 net57 net515 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1017 net515 net451 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu927 net451 net361 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu826 n224 net57 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu878 net188 net312 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu754 net361 net188 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu872 net184 net306 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu750 net394 net184 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu960 net483 net394 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu897 net306 net331 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu818 n219 net49 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1049 net49 net483 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu804 n155 net238 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu968 net209 net402 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1058 n50 net492 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu775 net492 net209 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu866 net179 net300 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu745 net393 net179 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu959 net481 net393 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu867 net300 net301 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu816 n103 net47 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1047 net47 net481 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1089 net72 net523 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1024 net523 net458 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu841 n228 net72 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu760 net367 net194 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu886 net194 net320 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu933 net458 net367 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu758 net364 net192 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu930 net454 net364 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1020 net520 net454 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu883 net192 net317 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu834 n229 net65 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1086 net65 net520 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1101 n226 net535 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1034 net535 net468 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu762 net380 net196 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu890 net196 net324 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu946 net468 net380 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu871 net183 net305 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu749 net392 net183 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu958 net482 net392 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu896 net305 net330 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu817 n223 net48 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1048 net48 net482 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu868 net180 net302 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu746 net388 net180 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu954 net475 net388 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu891 net302 net325 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu313 n227 net44 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1041 net44 net475 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu875 net187 net309 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu753 net398 net187 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu964 net488 net398 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu900 net309 net334 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu822 n231 net53 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1054 net53 net488 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu301 n221 net42 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1039 net42 net473 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu951 net473 net385 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu864 net178 net298 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu865 net298 net299 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu744 net385 net178 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu756 net363 net190 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu929 net453 net363 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1019 net519 net453 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu881 net190 net315 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu898 net307 net332 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1051 net50 net485 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu962 net485 net396 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu751 net396 net185 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu873 net185 net307 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu831 n222 net62 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1085 net62 net519 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu819 n220 net50 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xshift_register_reg[220] p_abuf102 net329 buft_net_99 shift_register[220] p_abuf17 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[135] p_abuf103 net409 buft_net_92 shift_register[135] p_abuf42 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[145] ftap_tck net238 buft_net_113 shift_register[145] p_abuf93 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[163] p_abuf102 net240 buft_net_92 shift_register[163] p_abuf34 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[126] p_abuf103 net239 buft_net_105 shift_register[126] p_abuf34 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[50] p_abuf97 n60 buft_net_106 shift_register[50] p_abuf82 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[158] p_abuf102 net413 buft_net_111 shift_register[158] p_abuf25 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[243] p_abuf99 net418 buft_net_108 shift_register[243] p_abuf18 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[128] p_abuf102 net390 buft_net_105 shift_register[128] p_abuf34 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[195] p_abuf103 n205 buft_net_105 shift_register[195] p_abuf47 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[200] p_abuf102 n210 buft_net_102 shift_register[200] p_abuf74 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[237] ftap_tck net435 buft_net_97 shift_register[237] p_abuf45 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[247] p_abuf99 n257 buft_net_108 shift_register[247] p_abuf78 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[54] p_abuf98 n64 buft_net_119 shift_register[54] p_abuf95 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[79] p_abuf98 n89 buft_net_94 shift_register[79] p_abuf35 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[212] p_abuf102 net315 buft_net_100 shift_register[212] p_abuf39 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[64] p_abuf100 n74 buft_net_91 shift_register[64] p_abuf96 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[44] p_abuf97 n54 buft_net_114 shift_register[44] p_abuf86 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[107] p_abuf101 n117 buft_net_96 shift_register[107] p_abuf66 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[26] p_abuf101 n36 buft_net_96 shift_register[26] p_abuf66 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[106] p_abuf101 n116 buft_net_96 shift_register[106] p_abuf66 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[176] p_abuf101 n186 buft_net_93 shift_register[176] p_abuf49 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[246] p_abuf99 n256 buft_net_108 shift_register[246] p_abuf42 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[229] ftap_tck n239 buft_net_97 shift_register[229] p_abuf45 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[183] p_abuf103 n193 buft_net_93 shift_register[183] p_abuf84 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[208] p_abuf102 net295 buft_net_100 shift_register[208] p_abuf27 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[49] p_abuf97 n59 buft_net_106 shift_register[49] p_abuf86 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[59] p_abuf100 n69 buft_net_91 shift_register[59] p_abuf95 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[219] p_abuf102 net317 buft_net_99 shift_register[219] p_abuf17 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[173] p_abuf101 n183 buft_net_93 shift_register[173] p_abuf49 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[43] p_abuf97 n53 buft_net_115 shift_register[43] p_abuf79 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[22] p_abuf100 net326 buft_net_121 shift_register[22] p_abuf38 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[61] p_abuf100 n71 buft_net_91 shift_register[61] p_abuf95 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[57] p_abuf100 n67 buft_net_107 shift_register[57] p_abuf95 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[177] p_abuf101 n187 buft_net_93 shift_register[177] p_abuf49 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[101] p_abuf101 n111 buft_net_120 shift_register[101] p_abuf89 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[245] p_abuf99 n255 buft_net_104 shift_register[245] p_abuf18 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[60] p_abuf100 n70 buft_net_107 shift_register[60] p_abuf76 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[249] p_abuf99 n259 buft_net_108 shift_register[249] p_abuf78 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[147] p_abuf98 n157 buft_net_113 shift_register[147] p_abuf21 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[75] p_abuf98 n85 buft_net_119 shift_register[75] p_abuf95 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[65] p_abuf100 n75 buft_net_91 shift_register[65] p_abuf96 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[228] p_abuf97 net456 buft_net_108 shift_register[228] p_abuf82 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[171] p_abuf103 n181 buft_net_98 shift_register[171] p_abuf23 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[181] p_abuf103 n191 buft_net_93 shift_register[181] p_abuf23 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[117] p_abuf97 n127 buft_net_117 shift_register[117] p_abuf61 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[35] p_abuf97 n45 buft_net_117 shift_register[35] p_abuf61 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[33] p_abuf97 n43 buft_net_117 shift_register[33] p_abuf61 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[127] p_abuf102 n137 buft_net_92 shift_register[127] p_abuf34 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[259] p_abuf99 n269 buft_net_109 shift_register[259] p_abuf30 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[256] p_abuf99 n266 buft_net_109 shift_register[256] p_abuf30 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[192] p_abuf102 n202 buft_net_102 shift_register[192] p_abuf37 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[23] p_abuf101 n33 buft_net_121 shift_register[23] p_abuf38 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[21] p_abuf100 n31 buft_net_121 shift_register[21] p_abuf38 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[56] p_abuf98 net411 buft_net_119 shift_register[56] p_abuf95 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[98] p_abuf101 n108 buft_net_121 shift_register[98] p_abuf38 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[140] p_abuf97 net428 buft_net_115 shift_register[140] p_abuf44 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[19] p_abuf100 net422 buft_net_107 shift_register[19] p_abuf16 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[262] p_abuf99 n272 buft_net_109 shift_register[262] p_abuf25 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[257] p_abuf99 n267 buft_net_109 shift_register[257] p_abuf25 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[223] p_abuf102 net426 buft_net_111 shift_register[223] p_abuf73 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[55] p_abuf98 n65 buft_net_119 shift_register[55] p_abuf95 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[238] p_abuf98 n248 buft_net_112 shift_register[238] p_abuf64 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[78] p_abuf98 n88 buft_net_110 shift_register[78] p_abuf32 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[38] p_abuf97 n48 buft_net_115 shift_register[38] p_abuf44 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[41] p_abuf97 n51 buft_net_115 shift_register[41] p_abuf44 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[42] p_abuf97 n52 buft_net_115 shift_register[42] p_abuf44 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[113] p_abuf101 n123 buft_net_120 shift_register[113] p_abuf62 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[99] p_abuf101 n109 buft_net_120 shift_register[99] p_abuf62 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[112] p_abuf101 n122 buft_net_120 shift_register[112] p_abuf62 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[13] p_abuf100 n23 buft_net_107 shift_register[13] p_abuf87 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[14] p_abuf100 n24 buft_net_107 shift_register[14] p_abuf16 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[15] p_abuf100 n25 buft_net_107 shift_register[15] p_abuf16 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[36] p_abuf97 n46 buft_net_106 shift_register[36] p_abuf83 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[104] p_abuf103 net429 buft_net_116 shift_register[104] p_abuf92 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[48] p_abuf97 n58 buft_net_115 shift_register[48] p_abuf59 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[114] p_abuf97 net297 buft_net_117 shift_register[114] p_abuf62 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[123] p_abuf103 n133 buft_net_105 shift_register[123] p_abuf42 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[103] p_abuf103 n113 buft_net_116 shift_register[103] p_abuf66 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[118] p_abuf97 net287 buft_net_116 shift_register[118] p_abuf91 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[164] p_abuf103 n174 buft_net_105 shift_register[164] p_abuf47 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[5] p_abuf98 n15 buft_net_112 shift_register[5] p_abuf64 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[30] p_abuf101 n40 buft_net_96 shift_register[30] p_abuf88 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[29] p_abuf101 n39 buft_net_96 shift_register[29] p_abuf88 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[3] p_abuf98 n13 buft_net_112 shift_register[3] p_abuf94 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[28] p_abuf101 n38 buft_net_96 shift_register[28] p_abuf88 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[167] p_abuf101 n177 buft_net_116 shift_register[167] p_abuf92 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[110] p_abuf97 n120 buft_net_117 shift_register[110] p_abuf62 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[115] p_abuf101 n125 buft_net_117 shift_register[115] p_abuf62 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[141] p_abuf98 n151 buft_net_110 shift_register[141] p_abuf59 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[109] p_abuf101 n119 buft_net_96 shift_register[109] p_abuf89 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[27] p_abuf101 n37 buft_net_96 shift_register[27] p_abuf89 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[105] p_abuf101 n115 buft_net_96 shift_register[105] p_abuf67 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[165] p_abuf103 n175 buft_net_105 shift_register[165] p_abuf92 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[210] p_abuf102 net332 buft_net_100 shift_register[210] p_abuf39 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[121] p_abuf103 n131 buft_net_105 shift_register[121] p_abuf91 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[53] p_abuf100 net242 buft_net_106 shift_register[53] p_abuf90 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[124] p_abuf103 n134 buft_net_105 shift_register[124] p_abuf91 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[211] p_abuf102 net299 buft_net_100 shift_register[211] p_abuf39 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[122] p_abuf103 n132 buft_net_105 shift_register[122] p_abuf91 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[221] p_abuf102 net334 buft_net_99 shift_register[221] p_abuf73 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[150] p_abuf98 n160 buft_net_112 shift_register[150] p_abuf20 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[217] p_abuf102 net325 buft_net_99 shift_register[217] p_abuf27 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[146] p_abuf98 n156 buft_net_112 shift_register[146] p_abuf20 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[8] p_abuf98 n18 buft_net_112 shift_register[8] p_abuf20 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[216] p_abuf102 net324 buft_net_99 shift_register[216] p_abuf27 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[7] p_abuf98 n17 buft_net_112 shift_register[7] p_abuf20 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[260] p_abuf99 net421 buft_net_111 shift_register[260] p_abuf31 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[218] p_abuf102 net320 buft_net_99 shift_register[218] p_abuf17 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[194] p_abuf102 net318 buft_net_102 shift_register[194] p_abuf40 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[46] p_abuf97 n56 buft_net_106 shift_register[46] p_abuf86 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[62] p_abuf100 n72 buft_net_97 shift_register[62] p_abuf48 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[45] p_abuf97 n55 buft_net_114 shift_register[45] p_abuf58 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[76] p_abuf98 n86 buft_net_119 shift_register[76] p_abuf59 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[92] p_abuf97 n102 buft_net_114 shift_register[92] p_abuf58 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[11] p_abuf98 n21 buft_net_110 shift_register[11] p_abuf20 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[137] p_abuf103 n147 buft_net_92 shift_register[137] p_abuf34 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[82] p_abuf99 n92 buft_net_94 shift_register[82] p_abuf35 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[34] p_abuf97 n44 buft_net_106 shift_register[34] p_abuf82 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[93] p_abuf97 net301 buft_net_114 shift_register[93] p_abuf82 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[162] p_abuf102 net245 buft_net_92 shift_register[162] p_abuf34 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[40] p_abuf98 net402 buft_net_110 shift_register[40] p_abuf55 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[1] p_abuf100 net335 buft_net_118 shift_register[1] p_abuf94 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[139] p_abuf97 n149 buft_net_114 shift_register[139] p_abuf86 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[142] p_abuf98 n152 buft_net_110 shift_register[142] p_abuf57 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[169] p_abuf103 n179 buft_net_103 shift_register[169] p_abuf24 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[153] p_abuf98 n163 buft_net_110 shift_register[153] p_abuf43 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[95] p_abuf101 n105 buft_net_121 shift_register[95] p_abuf38 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[6] p_abuf98 n16 buft_net_110 shift_register[6] p_abuf43 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[94] p_abuf101 n104 buft_net_121 shift_register[94] p_abuf38 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[160] p_abuf102 n170 buft_net_95 shift_register[160] p_abuf39 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[198] p_abuf102 n208 buft_net_102 shift_register[198] p_abuf40 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[202] p_abuf102 n212 buft_net_95 shift_register[202] p_abuf39 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[197] p_abuf102 n207 buft_net_102 shift_register[197] p_abuf40 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[193] p_abuf102 n203 buft_net_102 shift_register[193] p_abuf75 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[206] p_abuf102 n216 buft_net_102 shift_register[206] p_abuf36 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[196] p_abuf102 n206 buft_net_102 shift_register[196] p_abuf75 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[199] p_abuf102 n209 buft_net_102 shift_register[199] p_abuf36 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[190] p_abuf102 n200 buft_net_102 shift_register[190] p_abuf75 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[205] p_abuf102 n215 buft_net_92 shift_register[205] p_abuf74 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[258] p_abuf99 n268 buft_net_109 shift_register[258] p_abuf25 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[39] p_abuf97 net410 buft_net_115 shift_register[39] p_abuf44 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[240] p_abuf99 n250 buft_net_104 shift_register[240] p_abuf26 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[252] p_abuf99 n262 buft_net_101 shift_register[252] p_abuf28 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[185] p_abuf103 n195 buft_net_103 shift_register[185] p_abuf53 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[161] p_abuf102 n171 buft_net_92 shift_register[161] p_abuf39 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[187] p_abuf103 n197 buft_net_103 shift_register[187] p_abuf53 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[63] p_abuf100 n73 buft_net_97 shift_register[63] p_abuf94 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[182] p_abuf103 n192 buft_net_103 shift_register[182] p_abuf53 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[66] p_abuf100 n76 buft_net_97 shift_register[66] p_abuf94 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[186] p_abuf103 n196 buft_net_103 shift_register[186] p_abuf53 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[2] p_abuf98 n12 buft_net_112 shift_register[2] p_abuf57 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[47] p_abuf97 n57 buft_net_115 shift_register[47] p_abuf59 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[68] p_abuf100 n78 buft_net_119 shift_register[68] p_abuf96 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[20] p_abuf97 net370 buft_net_121 shift_register[20] p_abuf90 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[77] p_abuf98 n87 buft_net_115 shift_register[77] p_abuf59 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[111] p_abuf97 net327 buft_net_106 shift_register[111] p_abuf82 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[69] p_abuf100 n79 buft_net_118 shift_register[69] p_abuf94 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[71] p_abuf100 n81 buft_net_118 shift_register[71] p_abuf94 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[156] p_abuf99 n166 buft_net_104 shift_register[156] p_abuf19 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[73] p_abuf98 n83 buft_net_119 shift_register[73] p_abuf59 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[84] p_abuf99 n94 buft_net_101 shift_register[84] p_abuf79 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[149] p_abuf98 n159 buft_net_112 shift_register[149] p_abuf85 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[74] p_abuf98 n84 buft_net_119 shift_register[74] p_abuf64 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[31] p_abuf101 n41 buft_net_121 shift_register[31] reset_b vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[125] p_abuf103 n135 buft_net_105 shift_register[125] p_abuf42 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[148] p_abuf98 n158 buft_net_112 shift_register[148] p_abuf85 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[4] p_abuf98 n14 buft_net_112 shift_register[4] p_abuf94 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[209] p_abuf102 net331 buft_net_100 shift_register[209] p_abuf39 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[207] p_abuf102 net333 buft_net_95 shift_register[207] p_abuf39 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[129] p_abuf103 net366 buft_net_105 shift_register[129] p_abuf42 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[215] p_abuf102 net314 buft_net_95 shift_register[215] p_abuf39 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[37] p_abuf97 net248 buft_net_115 shift_register[37] p_abuf59 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[10] p_abuf98 n20 buft_net_110 shift_register[10] p_abuf60 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[16] p_abuf100 n26 buft_net_107 shift_register[16] p_abuf54 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[152] p_abuf98 n162 buft_net_110 shift_register[152] p_abuf60 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[51] p_abuf97 net407 buft_net_106 shift_register[51] p_abuf38 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[136] p_abuf102 net433 buft_net_92 shift_register[136] p_abuf17 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[17] p_abuf100 n27 buft_net_121 shift_register[17] p_abuf69 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[102] p_abuf101 net237 buft_net_120 shift_register[102] p_abuf89 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[67] p_abuf100 n77 buft_net_91 shift_register[67] p_abuf96 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[80] p_abuf99 n90 buft_net_94 shift_register[80] p_abuf77 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[83] p_abuf99 n93 buft_net_94 shift_register[83] p_abuf35 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[52] p_abuf100 net432 buft_net_121 shift_register[52] p_abuf90 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[12] p_abuf98 net323 buft_net_119 shift_register[12] p_abuf64 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[116] p_abuf101 n126 buft_net_117 shift_register[116] p_abuf63 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[97] p_abuf100 net328 buft_net_121 shift_register[97] reset_b vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[32] p_abuf101 n42 buft_net_121 shift_register[32] p_abuf88 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[203] p_abuf102 n213 buft_net_95 shift_register[203] p_abuf27 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[120] p_abuf101 n130 buft_net_116 shift_register[120] p_abuf92 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[232] ftap_tck n242 buft_net_97 shift_register[232] p_abuf22 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[189] p_abuf103 n199 buft_net_98 shift_register[189] p_abuf24 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[231] ftap_tck n241 buft_net_97 shift_register[231] p_abuf22 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[236] ftap_tck n246 buft_net_97 shift_register[236] p_abuf45 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[191] p_abuf102 n201 buft_net_102 shift_register[191] p_abuf37 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[174] p_abuf101 net419 buft_net_93 shift_register[174] p_abuf33 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[170] p_abuf103 n180 buft_net_103 shift_register[170] p_abuf24 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[91] p_abuf99 net236 buft_net_108 shift_register[91] p_abuf78 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[248] p_abuf99 n258 buft_net_104 shift_register[248] p_abuf58 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[263] p_abuf99 net403 buft_net_104 shift_register[263] p_abuf30 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[264] p_abuf98 net246 buft_net_101 shift_register[264] p_abuf35 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[25] p_abuf101 n35 buft_net_96 shift_register[25] p_abuf89 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[131] p_abuf103 n141 buft_net_108 shift_register[131] p_abuf42 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[188] p_abuf103 n198 buft_net_98 shift_register[188] p_abuf24 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[155] p_abuf99 n165 buft_net_104 shift_register[155] p_abuf30 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[180] p_abuf101 net416 buft_net_93 shift_register[180] p_abuf49 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[201] p_abuf102 n211 buft_net_92 shift_register[201] p_abuf41 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[72] p_abuf100 net372 buft_net_118 shift_register[72] p_abuf20 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[134] p_abuf103 n144 buft_net_108 shift_register[134] p_abuf18 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[204] p_abuf102 n214 buft_net_92 shift_register[204] p_abuf27 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[168] p_abuf101 net417 buft_net_96 shift_register[168] p_abuf66 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[227] p_abuf97 n237 buft_net_108 shift_register[227] p_abuf61 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[226] p_abuf97 n236 buft_net_108 shift_register[226] p_abuf82 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[175] p_abuf103 net427 buft_net_93 shift_register[175] p_abuf23 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[166] p_abuf103 net389 buft_net_116 shift_register[166] p_abuf47 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[151] p_abuf98 n161 buft_net_112 shift_register[151] p_abuf20 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[242] p_abuf99 n252 buft_net_108 shift_register[242] p_abuf18 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[130] p_abuf99 net244 buft_net_108 shift_register[130] p_abuf42 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[233] ftap_tck n243 buft_net_97 shift_register[233] p_abuf22 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[230] ftap_tck n240 buft_net_97 shift_register[230] p_abuf45 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[235] ftap_tck n245 buft_net_97 shift_register[235] p_abuf45 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[157] p_abuf99 net434 buft_net_104 shift_register[157] p_abuf18 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[241] p_abuf99 n251 buft_net_104 shift_register[241] p_abuf30 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[159] p_abuf99 net408 buft_net_111 shift_register[159] p_abuf73 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[144] ftap_tck n154 buft_net_113 shift_register[144] p_abuf93 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[133] p_abuf103 n143 buft_net_92 shift_register[133] p_abuf18 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[90] p_abuf99 n100 buft_net_104 shift_register[90] p_abuf58 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[85] p_abuf99 n95 buft_net_101 shift_register[85] p_abuf26 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[251] p_abuf99 n261 buft_net_104 shift_register[251] p_abuf26 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[267] p_abuf99 n277 buft_net_101 shift_register[267] p_abuf28 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[81] p_abuf99 n91 buft_net_94 shift_register[81] p_abuf46 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[255] p_abuf99 n265 buft_net_101 shift_register[255] p_abuf46 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[265] p_abuf99 n275 buft_net_94 shift_register[265] p_abuf46 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[89] p_abuf99 n99 buft_net_104 shift_register[89] p_abuf79 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[86] p_abuf99 n96 buft_net_101 shift_register[86] p_abuf79 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[88] p_abuf99 n98 buft_net_101 shift_register[88] p_abuf79 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[87] p_abuf99 n97 buft_net_101 shift_register[87] p_abuf79 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[268] p_abuf99 n278 buft_net_101 shift_register[268] p_abuf79 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[179] p_abuf101 n189 buft_net_93 shift_register[179] p_abuf23 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[266] p_abuf99 n276 buft_net_101 shift_register[266] p_abuf28 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[254] p_abuf99 n264 buft_net_109 shift_register[254] p_abuf28 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[18] p_abuf100 n28 buft_net_107 shift_register[18] p_abuf95 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[222] p_abuf99 net71 buft_net_111 shift_register[222] p_abuf31 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[132] p_abuf103 n142 buft_net_105 shift_register[132] p_abuf51 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[224] p_abuf99 net420 buft_net_111 shift_register[224] p_abuf31 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[119] p_abuf101 n129 buft_net_116 shift_register[119] p_abuf89 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[213] p_abuf102 net330 buft_net_99 shift_register[213] p_abuf27 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[96] p_abuf101 net247 buft_net_120 shift_register[96] p_abuf88 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[143] p_abuf98 net378 buft_net_113 shift_register[143] p_abuf85 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[9] p_abuf98 n19 buft_net_110 shift_register[9] p_abuf85 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[138] p_abuf103 net399 buft_net_105 shift_register[138] p_abuf34 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[70] p_abuf100 n80 buft_net_119 shift_register[70] p_abuf96 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[108] p_abuf97 net293 buft_net_117 shift_register[108] p_abuf61 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[58] p_abuf100 net241 buft_net_107 shift_register[58] p_abuf95 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[214] p_abuf102 net312 buft_net_100 shift_register[214] p_abuf39 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[24] p_abuf101 n34 buft_net_96 shift_register[24] p_abuf88 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[234] ftap_tck n244 buft_net_97 shift_register[234] p_abuf45 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[100] p_abuf97 net316 buft_net_117 shift_register[100] p_abuf62 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[239] p_abuf98 net243 buft_net_110 shift_register[239] p_abuf44 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[225] p_abuf102 net425 buft_net_111 shift_register[225] p_abuf25 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[184] p_abuf103 n194 buft_net_93 shift_register[184] p_abuf49 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[178] p_abuf101 n188 buft_net_93 shift_register[178] p_abuf33 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[244] p_abuf103 net415 buft_net_92 shift_register[244] p_abuf18 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[253] p_abuf99 n263 buft_net_101 shift_register[253] p_abuf46 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[154] p_abuf99 n164 buft_net_94 shift_register[154] p_abuf46 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[261] p_abuf102 net423 buft_net_109 shift_register[261] p_abuf25 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[172] p_abuf103 net424 buft_net_93 shift_register[172] p_abuf33 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xshift_register_reg[0] p_abuf100 n8 buft_net_118 data_reg_tdo p_abuf65 vdd vssx ringpll__b15fqn043al1n04x5 m=1
Xplace_binv_r_112 ropt_net_571 buft_net_112 vdd vssx ringpll__b15inv000ah1n03x5 m=1
Xplace_binv_r_96 ropt_net_571 buft_net_96 vdd vssx ringpll__b15inv000ah1n03x5 m=1
Xplace_binv_r_92 n468 buft_net_92 vdd vssx ringpll__b15inv000ah1n03x5 m=1
Xshift_register_reg[250] p_abuf99 n260 buft_net_104 shift_register[250] p_abuf78 vdd vssx ringpll__b15fqn043al1n02x3 m=1
Xplace_ainv_p_527 buf_net_462 buf_net_457 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_505 buf_net_441 buf_net_435 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_463 aps_rename_1434 buf_net_393 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_529 buf_net_462 buf_net_459 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_522 buf_net_462 buf_net_452 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_524 buf_net_463 buf_net_454 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_509 buf_net_441 buf_net_439 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_99 n468 buft_net_99 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_497 net_net_569 buf_net_427 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_124 buf_net_427 buft_net_124 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_494 net_net_569 buf_net_424 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_132 buf_net_424 buft_net_132 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_493 net_net_569 buf_net_423 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_486 net_net_569 buf_net_416 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_135 buf_net_416 buft_net_135 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_533 n4 buf_net_463 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_532 n4 buf_net_462 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_487 net_net_569 buf_net_417 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_126 buf_net_417 buft_net_126 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_rlb__598 buf_net_393 p_abuf12 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_455 buf_net_393 p_abuf10 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_160 p_abuf14 p_abuf5 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_500 net_net_569 buf_net_430 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_122 buf_net_430 buft_net_122 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_515 buf_net_463 buf_net_445 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_519 buf_net_463 buf_net_449 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_521 buf_net_462 buf_net_451 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_520 buf_net_462 buf_net_450 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_513 buf_net_462 buf_net_443 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_511 n811 buf_net_441 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_508 buf_net_441 buf_net_438 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_507 buf_net_441 buf_net_437 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_492 net_net_569 buf_net_422 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_491 net_net_569 buf_net_421 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_490 net_net_569 buf_net_420 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_488 net_net_569 buf_net_418 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_rlb__600 buf_net_393 p_abuf9 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_154 p_abuf71 p_abuf6 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_110 ropt_net_571 buft_net_110 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_106 ropt_net_571 buft_net_106 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_119 ropt_net_571 buft_net_119 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_115 ropt_net_571 buft_net_115 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_107 ropt_net_571 buft_net_107 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_116 n468 buft_net_116 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_109 n468 buft_net_109 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_111 n468 buft_net_111 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_102 n468 buft_net_102 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_94 n468 buft_net_94 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_158 p_abuf12 p_abuf4 vdd vssx ringpll__b15inv000ah1n05x5 m=1
Xplace_ainv_p_496 net_net_569 buf_net_426 vdd vssx ringpll__b15inv000ah1n05x5 m=1
Xpost_cts_optbinv_rr_2330 net_net_570 net_net_569 vdd vssx ringpll__b15inv000ah1n05x5 m=1
Xins_eco_214 net_eco_5 net_eco_4 vdd vssx ringpll__b15inv000ah1n05x5 m=1
Xins_eco_212 net_eco_3 net_eco_2 vdd vssx ringpll__b15inv000ah1n05x5 m=1
Xplace_binv_r_105 n468 buft_net_105 vdd vssx ringpll__b15inv000ah1n05x5 m=1
Xplace_binv_r_101 n468 buft_net_101 vdd vssx ringpll__b15inv000ah1n05x5 m=1
Xplace_binv_r_104 n468 buft_net_104 vdd vssx ringpll__b15inv000ah1n05x5 m=1
Xu10 shift_register[267] buf_net_451 n1011 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu741 stap_irdecoder_drselect n6 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu23 n1011 n276 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xins_eco_211 shift_register[129] net_net_569 net_eco_6 vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xins_eco_208 shift_register[128] net_net_569 net_eco_7 vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xins_eco_209 shift_register[104] net_net_569 net_eco_9 vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xins_eco_210 shift_register[127] net_net_569 net_eco_8 vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu19 stap_fsm_capture_dr n6 n811 vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu15 stap_fsm_shift_dr n6 stap_fsm_capture_dr n4 vdd vssx ringpll__b15nonb03ah1n03x5 m=1
Xeco_cell_5_0 eco_net_6_0 eco_net_5_0 vdd vssx ringpll__b15bfn000al1n08x5 m=1
Xeco_cell_4_0 eco_net_6_0 eco_net_4_0 vdd vssx ringpll__b15bfn000al1n08x5 m=1
Xeco_cell_3_0 eco_net_6_0 eco_net_3_0 vdd vssx ringpll__b15bfn000al1n08x5 m=1
Xeco_cell_1_0 eco_net_2_0 eco_net_1_0 vdd vssx ringpll__b15bfn000al1n08x5 m=1
Xeco_cell_0 eco_net_2_0 eco_net_0 vdd vssx ringpll__b15bfn000al1n08x5 m=1
Xeco_cell eco_net_2_0 eco_net vdd vssx ringpll__b15bfn000al1n08x5 m=1
Xeco_cell_6_0 net_eco_4 eco_net_6_0 vdd vssx ringpll__b15bfn000al1n08x5 m=1
Xeco_cell_2_0 net_eco_2 eco_net_2_0 vdd vssx ringpll__b15bfn000al1n08x5 m=1
Xtdr_data_out_reg[129] net_eco_1 net_eco_6 tdr_data_out[129] tieoff_net_eco_6 reset_b p0 tieoff_net_eco_7 vdd vssx ringpll__b15fqy08fal1n02x5 m=1
Xtdr_data_out_reg[104] net_eco_1 net_eco_9 tdr_data_out[104] tieoff_net_eco_0 reset_b p0 tieoff_net_eco_1 vdd vssx ringpll__b15fqy08fal1n02x5 m=1
Xtdr_data_out_reg[127] net_eco_1 net_eco_8 tdr_data_out[127] tieoff_net_eco_2 reset_b p0 tieoff_net_eco_3 vdd vssx ringpll__b15fqy08fal1n02x5 m=1
Xtdr_data_out_reg[128] net_eco_1 net_eco_7 tdr_data_out[128] tieoff_net_eco_4 reset_b p0 tieoff_net_eco_5 vdd vssx ringpll__b15fqy08fal1n02x5 m=1
Xtieoff_cell_eco_7 tieoff_net_eco_7 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xtieoff_cell_eco_6 tieoff_net_eco_6 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xtieoff_cell_eco_5 tieoff_net_eco_5 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xtieoff_cell_eco_4 tieoff_net_eco_4 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xtieoff_cell_eco_1 tieoff_net_eco_1 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xtieoff_cell_eco_0 tieoff_net_eco_0 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xtieoff_cell_eco_3 tieoff_net_eco_3 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xtieoff_cell_eco_2 tieoff_net_eco_2 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xrouteropt_mt_inst_2331 n468 ropt_net_571 vdd vssx ringpll__b15bfn001ah1n06x5 m=1
Xplace_ainv_p_495 net_net_569 buf_net_425 vdd vssx ringpll__b15inv020an1n05x5 m=1
Xplace_binv_r_156 p_abuf7 p_abuf1 vdd vssx ringpll__b15inv020ah1n05x5 m=1
Xu4 stap_fsm_update_dr n6 net_net_570 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu740 buf_net_454 buf_net_439 n468 vdd vssx ringpll__b15nor002ah1n06x5 m=1
Xclk_gate_tdr_data_out_reg_latch ftap_tck net_eco_1 net_net_570 p0 vdd vssx ringpll__b15cilb81al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ljpll_idv
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ljpll_idv dfx__openloop dfx__vco_trim_pg[3] dfx__vco_trim_pg[2] dfx__vco_trim_pg[1] dfx__vco_trim_pg[0] dfx__vco_trim_cb[2] dfx__vco_trim_cb[1] dfx__vco_trim_cb[0] idv_fub__idvaddrth[9] idv_fub__idvaddrth[8] idv_fub__idvaddrth[7] idv_fub__idvaddrth[6] idv_fub__idvaddrth[5] idv_fub__idvaddrth[4] idv_fub__idvaddrth[3] idv_fub__idvaddrth[2] idv_fub__idvaddrth[1] idv_fub__idvaddrth[0] idv_fub__idvdisableth idv__rdacctlth[3] idv__rdacctlth[2] idv__rdacctlth[1] idv__rdacctlth[0] idv__cbctlth[2] idv__cbctlth[1] idv__cbctlth[0] idv__pgctlth[3] idv__pgctlth[2] idv__pgctlth[1] idv__pgctlth[0] vdd vssx
* .PININFO dfx__openloop:I dfx__vco_trim_cb[2]:I dfx__vco_trim_cb[1]:I dfx__vco_trim_cb[0]:I dfx__vco_trim_pg[3]:I dfx__vco_trim_pg[2]:I
* .PININFO dfx__vco_trim_pg[1]:I dfx__vco_trim_pg[0]:I idv_fub__idvaddrth[9]:I idv_fub__idvaddrth[8]:I idv_fub__idvaddrth[7]:I idv_fub__idvaddrth[6]:I
* .PININFO idv_fub__idvaddrth[5]:I idv_fub__idvaddrth[4]:I idv_fub__idvaddrth[3]:I idv_fub__idvaddrth[2]:I idv_fub__idvaddrth[1]:I
* .PININFO idv_fub__idvaddrth[0]:I idv_fub__idvdisableth:I vdd:I vssx:I idv__cbctlth[2]:O idv__cbctlth[1]:O idv__cbctlth[0]:O idv__pgctlth[3]:O
* .PININFO idv__pgctlth[2]:O idv__pgctlth[1]:O idv__pgctlth[0]:O idv__rdacctlth[3]:O idv__rdacctlth[2]:O idv__rdacctlth[1]:O idv__rdacctlth[0]:O
Xu16 idv_fub__idvaddrth[6] n4 idv__rdacctlth[0] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu15 idv_fub__idvaddrth[7] n4 idv__rdacctlth[1] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu14 idv_fub__idvaddrth[8] n4 idv__rdacctlth[2] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu13 idv_fub__idvaddrth[9] n4 idv__rdacctlth[3] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu12 dfx__vco_trim_cb[0] n5 idv__cbctlth[0] vdd vssx ringpll__b15nonb02ah1n02x3 m=1
Xu3 n4 n5 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu6 n5 idv_fub__idvaddrth[1] dfx__vco_trim_pg[1] n4 idv__pgctlth[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu7 n5 idv_fub__idvaddrth[0] dfx__vco_trim_pg[0] n4 idv__pgctlth[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu5 n5 idv_fub__idvaddrth[2] dfx__vco_trim_pg[2] n4 idv__pgctlth[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu4 n5 idv_fub__idvaddrth[3] dfx__vco_trim_pg[3] n4 idv__pgctlth[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu2 idv_fub__idvdisableth dfx__openloop n4 vdd vssx ringpll__b15nanb02al1n04x5 m=1
Xu8 n4 dfx__vco_trim_cb[2] n1 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu10 n4 dfx__vco_trim_cb[1] n2 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu11 n2 n4 idv_fub__idvaddrth[4] idv__cbctlth[1] vdd vssx ringpll__b15oai012an1n03x5 m=1
Xu9 n1 n4 idv_fub__idvaddrth[5] idv__cbctlth[2] vdd vssx ringpll__b15oai012ah1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    idv_fublet
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__idv_fublet clkidvih idv_fub__idvaddrth[9] idv_fub__idvaddrth[8] idv_fub__idvaddrth[7] idv_fub__idvaddrth[6] idv_fub__idvaddrth[5] idv_fub__idvaddrth[4] idv_fub__idvaddrth[3] idv_fub__idvaddrth[2] idv_fub__idvaddrth[1] idv_fub__idvaddrth[0] idv_fub__idvdisableth idv_fub__idvgateennh idvdisable_bi idvdisable_bo idvfreqai idvfreqao idvfreqbi idvfreqbo idvpulsei idvpulseo idvtclki idvtctrli idvtctrlo idvtdi idvtdo idvtresi idvtreso p_abuf0 vdd vssx
* .PININFO clkidvih:I idvdisable_bi:I idvfreqai:I idvfreqbi:I idvpulsei:I idvtclki:I idvtctrli:I idvtdi:I idvtresi:I p_abuf0:I vdd:I vssx:I
* .PININFO idv_fub__idvaddrth[9]:O idv_fub__idvaddrth[8]:O idv_fub__idvaddrth[7]:O idv_fub__idvaddrth[6]:O idv_fub__idvaddrth[5]:O
* .PININFO idv_fub__idvaddrth[4]:O idv_fub__idvaddrth[3]:O idv_fub__idvaddrth[2]:O idv_fub__idvaddrth[1]:O idv_fub__idvaddrth[0]:O
* .PININFO idv_fub__idvdisableth:O idv_fub__idvgateennh:O idvdisable_bo:O idvfreqao:O idvfreqbo:O idvpulseo:O idvtctrlo:O idvtdo:O idvtreso:O
Xu17 idvfreqbi idvfreqbo vdd vssx ringpll__b15inv040al1n02x5 m=1
Xrouteropt_h_inst_2332 ropt_net_573 ropt_net_572 vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu20 idvtresi idvtreso vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu5 idvdisable_bi idvdisable_bo vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu4 idvpulsei idvpulseo vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu19 fublet_0_xfubletentmpth_b idvtctrli fublet_0_xdlyen_idvfubletaddrtmpth vdd vssx ringpll__b15nor002an1n06x5 m=1
Xfublet0xidvfubletaddrtmpth_reg[3] idvtclki idv_fub__idvaddrth[2] fublet_0_xdlyen_idvfubletaddrtmpth idv_fub__idvaddrth[3] n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xfublet0xidvfubletaddrtmpth_reg[5] idvtclki idv_fub__idvaddrth[4] fublet_0_xdlyen_idvfubletaddrtmpth idv_fub__idvaddrth[5] n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xfublet0xidvfubletaddrtmpth_reg[4] idvtclki idv_fub__idvaddrth[3] fublet_0_xdlyen_idvfubletaddrtmpth idv_fub__idvaddrth[4] n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xfublet0xidvfubletaddrtmpth_reg[8] idvtclki idv_fub__idvaddrth[7] fublet_0_xdlyen_idvfubletaddrtmpth idv_fub__idvaddrth[8] n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xfublet0xidvfubletaddrtmpth_reg[2] idvtclki idv_fub__idvaddrth[1] fublet_0_xdlyen_idvfubletaddrtmpth idv_fub__idvaddrth[2] n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xfublet0xidvfubletaddrtmpth_reg[6] idvtclki idv_fub__idvaddrth[5] fublet_0_xdlyen_idvfubletaddrtmpth idv_fub__idvaddrth[6] n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xfublet0xidvfubletaddrtmpth_reg[0] idvtclki idvaddr0nxtth_0 fublet_0_xdlyen_idvfubletaddrtmpth idv_fub__idvaddrth[0] n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xfublet0xidvfubletaddrtmpth_reg[1] idvtclki idv_fub__idvaddrth[0] fublet_0_xdlyen_idvfubletaddrtmpth idv_fub__idvaddrth[1] n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xfublet0xidvfubletaddrtmpth_reg[7] idvtclki idv_fub__idvaddrth[6] fublet_0_xdlyen_idvfubletaddrtmpth idv_fub__idvaddrth[7] n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xfublet0xidvfubletaddrtmpth_reg[9] idvtclki idv_fub__idvaddrth[8] fublet_0_xdlyen_idvfubletaddrtmpth idv_fub__idvaddrth[9] n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xfublet0xfubletentmpth_b_reg idvtclki fublet_0_xdlyin_fubletentmpth_b_0 idvtctrli fublet_0_xfubletentmpth_b n12 vdd vssx ringpll__b15fqn043al1n02x5 m=1
Xu15 idvtdi fublet_0_xdlyin_fubletentmpth_b_0 vdd vssx ringpll__b15inv020al1n05x5 m=1
Xu14 clkidvih idvfreqai idvfreqao vdd vssx ringpll__b15xnr002an1n02x5 m=1
Xu3 idvtresi n12 vdd vssx ringpll__b15inv000ah1n03x5 m=1
Xu18 idvpulsei fublet_0_xdlyin_fubletentmpth_b_0 idvaddr0nxtth_0 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xrouteropt_h_inst_2333 cts0 ropt_net_573 vdd vssx ringpll__b15bfn000al1n03x5 m=1
Xcts_idvtclki_bdp696 p_abuf0 cts0 vdd vssx ringpll__b15cbf000ah1n08x5 m=1
Xu8 n4 n1 n6 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu21 idvdisable_bi n12 n3 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu24 p_abuf0 n12 n21 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu29 net6 net7 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu28 n22 net6 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu2 net1 net2 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu16 net2 net3 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu26 net3 net4 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1 n16 net1 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu27 net4 net5 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu25 n21 idvdisable_bi n15 vdd vssx ringpll__b15nanb02al1n02x5 m=1
Xtctrltl_reg[0] n21 net7 idvtctrlo vdd vssx ringpll__b15lsn000al1n02x3 m=1
Xtdotl_reg[0] n15 net5 idvtdo vdd vssx ringpll__b15lsn000al1n02x3 m=1
Xu12 idvtctrli n12 ropt_net_572 n22 vdd vssx ringpll__b15nano22al1n03x5 m=1
Xu23 n8 idv_fub__idvaddrth[9] fublet_0_xdlyen_idvfubletaddrtmpth n2 vdd vssx ringpll__b15oaib12en1n02x5 m=1
Xu11 n3 ropt_net_572 n2 n16 vdd vssx ringpll__b15nor003al1n02x7 m=1
Xu22 fublet_0_xfubletentmpth_b idvtctrli fublet_0_xdlyin_fubletentmpth_b_0 n8 vdd vssx ringpll__b15oai012an1n02x5 m=1
Xu7 idv_fub__idvaddrth[2] idv_fub__idvaddrth[3] idv_fub__idvaddrth[1] idv_fub__idvaddrth[0] n1 vdd vssx ringpll__b15nor004al1n02x3 m=1
Xu6 idv_fub__idvaddrth[6] idv_fub__idvaddrth[7] idv_fub__idvaddrth[5] idv_fub__idvaddrth[8] n4 vdd vssx ringpll__b15nor004al1n02x3 m=1
Xu9 idvdisable_bi idvpulsei fublet_0_xfubletentmpth_b n5 vdd vssx ringpll__b15nonb03al1n02x5 m=1
Xu13 idv_fub__idvdisableth idv_fub__idvgateennh vdd vssx ringpll__b15inv040an1n03x5 m=1
Xu10 n5 idv_fub__idvaddrth[4] idv_fub__idvaddrth[9] n6 idv_fub__idvdisableth vdd vssx ringpll__b15oai013al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ljpll_dfx
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ljpll_dfx adc_ctl__startxxh bypassnnnnh dfx__adc_chop_en dfx__adc_clkdiv[1] dfx__adc_clkdiv[0] dfx__adc_freeze dfx__adc_sel_in[2] dfx__adc_sel_in[1] dfx__adc_sel_in[0] dfx__adc_start dfx__adc_start_cnt[1] dfx__adc_start_cnt[0] dfx__adc_use_vref dfx__bypass dfx__cp1_trim[4] dfx__cp1_trim[3] dfx__cp1_trim[2] dfx__cp1_trim[1] dfx__cp1_trim[0] dfx__cp2_trim[4] dfx__cp2_trim[3] dfx__cp2_trim[2] dfx__cp2_trim[1] dfx__cp2_trim[0] dfx__cpnbias[1] dfx__cpnbias[0] dfx__dca_cb[1] dfx__dca_cb[0] dfx__dca_ctrl[5] dfx__dca_ctrl[4] dfx__dca_ctrl[3] dfx__dca_ctrl[2] dfx__dca_ctrl[1] dfx__dca_ctrl[0] dfx__disable_run_upd dfx__fracstepnh[23] dfx__fracstepnh[22] dfx__fracstepnh[21] dfx__fracstepnh[20] dfx__fracstepnh[19] dfx__fracstepnh[18] dfx__fracstepnh[17] dfx__fracstepnh[16] dfx__fracstepnh[15] dfx__fracstepnh[14] dfx__fracstepnh[13] dfx__fracstepnh[12] dfx__fracstepnh[11] dfx__fracstepnh[10] dfx__fracstepnh[9] dfx__fracstepnh[8] dfx__fracstepnh[7] dfx__fracstepnh[6] dfx__fracstepnh[5] dfx__fracstepnh[4] dfx__fracstepnh[3] dfx__fracstepnh[2] dfx__fracstepnh[1] dfx__fracstepnh[0] dfx__fraction[23] dfx__fraction[22] dfx__fraction[21] dfx__fraction[20] dfx__fraction[19] dfx__fraction[18] dfx__fraction[17] dfx__fraction[16] dfx__fraction[15] dfx__fraction[14] dfx__fraction[13] dfx__fraction[12] dfx__fraction[11] dfx__fraction[10] dfx__fraction[9] dfx__fraction[8] dfx__fraction[7] dfx__fraction[6] dfx__fraction[5] dfx__fraction[4] dfx__fraction[3] dfx__fraction[2] dfx__fraction[1] dfx__fraction[0] dfx__fz_irefgen_a[4] dfx__fz_irefgen_a[3] dfx__fz_irefgen_a[2] dfx__fz_irefgen_a[1] dfx__fz_irefgen_a[0] dfx__fz_ldo_bypass_a dfx__fz_ldo_extrefsel_a dfx__fz_ldo_faststart_a dfx__fz_ldo_fbtrim_a[3] dfx__fz_ldo_fbtrim_a[2] dfx__fz_ldo_fbtrim_a[1] dfx__fz_ldo_fbtrim_a[0] dfx__fz_ldo_reftrim_a[3] dfx__fz_ldo_reftrim_a[2] dfx__fz_ldo_reftrim_a[1] dfx__fz_ldo_reftrim_a[0] dfx__fz_ldo_vinvoltsel_a[1] dfx__fz_ldo_vinvoltsel_a[0] dfx__fz_lockcnt_a[2] dfx__fz_lockcnt_a[1] dfx__fz_lockcnt_a[0] dfx__fz_lockforce_a dfx__fz_lpfclksel_a dfx__fz_nopfdpwrgate_a dfx__fz_pfd_pw_a[2] dfx__fz_pfd_pw_a[1] dfx__fz_pfd_pw_a[0] dfx__fz_pfddly_a[1] dfx__fz_pfddly_a[0] dfx__fz_spare_a[4] dfx__fz_spare_a[3] dfx__fz_spare_a[2] dfx__fz_spare_a[1] dfx__fz_spare_a[0] dfx__fz_startup_a[5] dfx__fz_startup_a[4] dfx__fz_startup_a[3] dfx__fz_startup_a[2] dfx__fz_startup_a[1] dfx__fz_startup_a[0] dfx__fz_vcosel_a dfx__fz_vcotrim_a[10] dfx__fz_vcotrim_a[9] dfx__fz_vcotrim_a[8] dfx__fz_vcotrim_a[7] dfx__fz_vcotrim_a[6] dfx__fz_vcotrim_a[5] dfx__fz_vcotrim_a[4] dfx__fz_vcotrim_a[3] dfx__fz_vcotrim_a[2] dfx__fz_vcotrim_a[1] dfx__fz_vcotrim_a[0] dfx__globalalignxxl dfx__ldo_enable_a dfx__lockstickyb dfx__lockthresh[3] dfx__lockthresh[2] dfx__lockthresh[1] dfx__lockthresh[0] dfx__mash_order_plus_one dfx__mdiv_ratio_a[5] dfx__mdiv_ratio_a[4] dfx__mdiv_ratio_a[3] dfx__mdiv_ratio_a[2] dfx__mdiv_ratio_a[1] dfx__mdiv_ratio_a[0] dfx__openloop dfx__pfd_residual_pw[2] dfx__pfd_residual_pw[1] dfx__pfd_residual_pw[0] dfx__powergood dfx__ratio[9] dfx__ratio[8] dfx__ratio[7] dfx__ratio[6] dfx__ratio[5] dfx__ratio[4] dfx__ratio[3] dfx__ratio[2] dfx__ratio[1] dfx__ratio[0] dfx__ratio_update_req dfx__reset_b dfx__skadj_ctrl[4] dfx__skadj_ctrl[3] dfx__skadj_ctrl[2] dfx__skadj_ctrl[1] dfx__skadj_ctrl[0] dfx__ssc_cyc_to_peak_m1[8] dfx__ssc_cyc_to_peak_m1[7] dfx__ssc_cyc_to_peak_m1[6] dfx__ssc_cyc_to_peak_m1[5] dfx__ssc_cyc_to_peak_m1[4] dfx__ssc_cyc_to_peak_m1[3] dfx__ssc_cyc_to_peak_m1[2] dfx__ssc_cyc_to_peak_m1[1] dfx__ssc_cyc_to_peak_m1[0] dfx__ssc_en dfx__ssc_prof_update_req dfx__sscdfxennh dfx__sscmodclkdivnh[1] dfx__sscmodclkdivnh[0] dfx__sscmodstepsnh[1] dfx__sscmodstepsnh[0] dfx__sscmodtrignh dfx__start_measurement dfx__ta_ldo_hiz_debug dfx__ta_ldo_idq_debug dfx__ta_openloop2 dfx__ta_spare[4] dfx__ta_spare[3] dfx__ta_spare[2] dfx__ta_spare[1] dfx__ta_spare[0] dfx__ta_vctlrdac[3] dfx__ta_vctlrdac[2] dfx__ta_vctlrdac[1] dfx__ta_vctlrdac[0] dfx__tight_loop dfx__tllm_en dfx__vcodiv_ratio_a[1] dfx__vcodiv_ratio_a[0] dfx__viewanaennnnnh[1] dfx__viewanaennnnnh[0] dfx__viewdigennnnnh[1] dfx__viewdigennnnnh[0] dfx__viewselnnnnh[9] dfx__viewselnnnnh[8] dfx__viewselnnnnh[7] dfx__viewselnnnnh[6] dfx__viewselnnnnh[5] dfx__viewselnnnnh[4] dfx__viewselnnnnh[3] dfx__viewselnnnnh[2] dfx__viewselnnnnh[1] dfx__viewselnnnnh[0] dfx__zdiv0_ratio_a[9] dfx__zdiv0_ratio_a[8] dfx__zdiv0_ratio_a[7] dfx__zdiv0_ratio_a[6] dfx__zdiv0_ratio_a[5] dfx__zdiv0_ratio_a[4] dfx__zdiv0_ratio_a[3] dfx__zdiv0_ratio_a[2] dfx__zdiv0_ratio_a[1] dfx__zdiv0_ratio_a[0] dfx__zdiv0_ratio_p5_a dfx__zdiv1_ratio_a[9] dfx__zdiv1_ratio_a[8] dfx__zdiv1_ratio_a[7] dfx__zdiv1_ratio_a[6] dfx__zdiv1_ratio_a[5] dfx__zdiv1_ratio_a[4] dfx__zdiv1_ratio_a[3] dfx__zdiv1_ratio_a[2] dfx__zdiv1_ratio_a[1] dfx__zdiv1_ratio_a[0] dfx__zdiv1_ratio_p5_a dfx_out[11] dfx_out[10] dfx_out[9] dfx_out[8] dfx_out[7] dfx_out[6] dfx_out[5] dfx_out[4] dfx_out[3] dfx_out[2] dfx_out[1] dfx_out[0] fractionnnnnh[23] fractionnnnnh[22] fractionnnnnh[21] fractionnnnnh[20] fractionnnnnh[19] fractionnnnnh[18] fractionnnnnh[17] fractionnnnnh[16] fractionnnnnh[15] fractionnnnnh[14] fractionnnnnh[13] fractionnnnnh[12] fractionnnnnh[11] fractionnnnnh[10] fractionnnnnh[9] fractionnnnnh[8] fractionnnnnh[7] fractionnnnnh[6] fractionnnnnh[5] fractionnnnnh[4] fractionnnnnh[3] fractionnnnnh[2] fractionnnnnh[1] fractionnnnnh[0] fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] fz_cpnbias[1] fz_cpnbias[0] fz_dca_cb[1] fz_dca_cb[0] fz_dca_ctrl[5] fz_dca_ctrl[4] fz_dca_ctrl[3] fz_dca_ctrl[2] fz_dca_ctrl[1] fz_dca_ctrl[0] fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] fz_ldo_bypass fz_ldo_extrefsel fz_ldo_faststart fz_ldo_fbtrim[3] fz_ldo_fbtrim[2] fz_ldo_fbtrim[1] fz_ldo_fbtrim[0] fz_ldo_reftrim[3] fz_ldo_reftrim[2] fz_ldo_reftrim[1] fz_ldo_reftrim[0] fz_ldo_vinvoltsel[1] fz_ldo_vinvoltsel[0] fz_lockcnt[2] fz_lockcnt[1] fz_lockcnt[0] fz_lockforce fz_lockstickyb fz_lockthresh[3] fz_lockthresh[2] fz_lockthresh[1] fz_lockthresh[0] fz_lpfclksel fz_nopfdpwrgate fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] fz_pfddly[1] fz_pfddly[0] fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] fz_spare[4] fz_spare[3] fz_spare[2] fz_spare[1] fz_spare[0] fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] fz_tight_loopb fz_vcosel fz_vcotrim[10] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] idv_fub__idv_out_idvdisable_bo idv_fub__idv_out_idvfreqao idv_fub__idv_out_idvfreqbo idv_fub__idv_out_idvpulseo idv_fub__idv_out_idvtclko idv_fub__idv_out_idvtctrlo idv_fub__idv_out_idvtdo idv_fub__idv_out_idvtreso iref_ctrl__irefdonexxh ldo_enable lock_detector__rawlockxxnnnl lock_timer__locktimecntxxnnnh[11] lock_timer__locktimecntxxnnnh[10] lock_timer__locktimecntxxnnnh[9] lock_timer__locktimecntxxnnnh[8] lock_timer__locktimecntxxnnnh[7] lock_timer__locktimecntxxnnnh[6] lock_timer__locktimecntxxnnnh[5] lock_timer__locktimecntxxnnnh[4] lock_timer__locktimecntxxnnnh[3] lock_timer__locktimecntxxnnnh[2] lock_timer__locktimecntxxnnnh[1] lock_timer__locktimecntxxnnnh[0] lockxxnnnl mash__halfintmxh mash__ratiomxh[9] mash__ratiomxh[8] mash__ratiomxh[7] mash__ratiomxh[6] mash__ratiomxh[5] mash__ratiomxh[4] mash__ratiomxh[3] mash__ratiomxh[2] mash__ratiomxh[1] mash__ratiomxh[0] mash_order_plus_one mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] p_abuf0 p_abuf1 p_abuf2 p_abuf3 p_abuf4 p_abuf5 p_abuf6 p_abuf7 p_abuf8 p_abuf9 p_abuf10 p_abuf11 p_abuf12 p_abuf13 p_abuf14 p_abuf15 p_abuf16 p_aps0 p_aps1 plldistpwrgoodnnnnh rationnnnh[9] rationnnnh[8] rationnnnh[7] rationnnnh[6] rationnnnh[5] rationnnnh[4] rationnnnh[3] rationnnnh[2] rationnnnh[1] rationnnnh[0] reg_req_ack__ratioupdackmxh reg_req_ack__sscprofupdackmxh reset_b_nnnnh reset_sync__reset_b_xxnnnl ssc_cyc_to_peak_m1[8] ssc_cyc_to_peak_m1[7] ssc_cyc_to_peak_m1[6] ssc_cyc_to_peak_m1[5] ssc_cyc_to_peak_m1[4] ssc_cyc_to_peak_m1[3] ssc_cyc_to_peak_m1[2] ssc_cyc_to_peak_m1[1] ssc_cyc_to_peak_m1[0] ssc_en ssc_frac_step[23] ssc_frac_step[22] ssc_frac_step[21] ssc_frac_step[20] ssc_frac_step[19] ssc_frac_step[18] ssc_frac_step[17] ssc_frac_step[16] ssc_frac_step[15] ssc_frac_step[14] ssc_frac_step[13] ssc_frac_step[12] ssc_frac_step[11] ssc_frac_step[10] ssc_frac_step[9] ssc_frac_step[8] ssc_frac_step[7] ssc_frac_step[6] ssc_frac_step[5] ssc_frac_step[4] ssc_frac_step[3] ssc_frac_step[2] ssc_frac_step[1] ssc_frac_step[0] ssc_mod_dfx__modulatorennh ssc_mod_dfx__triggerregxdh startup_gen__pfdenxxh tap_in[206] tap_in[205] tap_in[204] tap_in[203] tap_in[202] tap_in[201] tap_in[200] tap_in[199] tap_in[198] tap_in[197] tap_in[196] tap_in[195] tap_in[194] tap_in[193] tap_in[192] tap_in[191] tap_in[190] tap_in[189] tap_in[188] tap_in[187] tap_in[186] tap_in[185] tap_in[184] tap_in[183] tap_in[182] tap_in[181] tap_in[180] tap_in[179] tap_in[178] tap_in[177] tap_in[176] tap_in[175] tap_in[174] tap_in[173] tap_in[172] tap_in[171] tap_in[170] tap_in[169] tap_in[168] tap_in[167] tap_in[166] tap_in[165] tap_in[164] tap_in[163] tap_in[162] tap_in[161] tap_in[160] tap_in[159] tap_in[158] tap_in[157] tap_in[156] tap_in[155] tap_in[154] tap_in[153] tap_in[152] tap_in[151] tap_in[150] tap_in[149] tap_in[148] tap_in[147] tap_in[146] tap_in[145] tap_in[144] tap_in[143] tap_in[142] tap_in[141] tap_in[140] tap_in[139] tap_in[138] tap_in[137] tap_in[136] tap_in[135] tap_in[134] tap_in[133] tap_in[132] tap_in[131] tap_in[130] tap_in[129] tap_in[128] tap_in[127] tap_in[126] tap_in[125] tap_in[124] tap_in[123] tap_in[122] tap_in[121] tap_in[120] tap_in[119] tap_in[118] tap_in[117] tap_in[116] tap_in[115] tap_in[114] tap_in[113] tap_in[112] tap_in[111] tap_in[110] tap_in[109] tap_in[108] tap_in[107] tap_in[106] tap_in[105] tap_in[104] tap_in[103] tap_in[102] tap_in[101] tap_in[100] tap_in[99] tap_in[98] tap_in[97] tap_in[96] tap_in[95] tap_in[94] tap_in[93] tap_in[92] tap_in[91] tap_in[90] tap_in[89] tap_in[88] tap_in[87] tap_in[86] tap_in[85] tap_in[84] tap_in[83] tap_in[82] tap_in[81] tap_in[80] tap_in[79] tap_in[78] tap_in[77] tap_in[76] tap_in[75] tap_in[74] tap_in[73] tap_in[72] tap_in[71] tap_in[70] tap_in[69] tap_in[68] tap_in[67] tap_in[66] tap_in[65] tap_in[64] tap_in[63] tap_in[62] tap_in[61] tap_in[60] tap_in[59] tap_in[58] tap_in[57] tap_in[56] tap_in[55] tap_in[54] tap_in[53] tap_in[52] tap_in[51] tap_in[50] tap_in[49] tap_in[48] tap_in[47] tap_in[46] tap_in[45] tap_in[44] tap_in[43] tap_in[42] tap_in[41] tap_in[40] tap_in[39] tap_in[38] tap_in[37] tap_in[36] tap_in[35] tap_in[34] tap_in[33] tap_in[32] tap_in[31] tap_in[30] tap_in[29] tap_in[28] tap_in[27] tap_in[26] tap_in[25] tap_in[24] tap_in[23] tap_in[22] tap_in[21] tap_in[20] tap_in[19] tap_in[18] tap_in[17] tap_in[16] tap_in[15] tap_in[14] tap_in[13] tap_in[12] tap_in[11] tap_in[10] tap_in[9] tap_in[8] tap_in[7] tap_in[6] tap_in[5] tap_in[4] tap_in[3] tap_in[2] tap_in[1] tap_in[0] tap_out[61] tap_out[60] tap_out[59] tap_out[58] tap_out[57] tap_out[56] tap_out[55] tap_out[54] tap_out[53] tap_out[52] tap_out[51] tap_out[50] tap_out[49] tap_out[48] tap_out[47] tap_out[46] tap_out[45] tap_out[44] tap_out[43] tap_out[42] tap_out[41] tap_out[40] tap_out[39] tap_out[38] tap_out[37] tap_out[36] tap_out[35] tap_out[34] tap_out[33] tap_out[32] tap_out[31] tap_out[30] tap_out[29] tap_out[28] tap_out[27] tap_out[26] tap_out[25] tap_out[24] tap_out[23] tap_out[22] tap_out[21] tap_out[20] tap_out[19] tap_out[18] tap_out[17] tap_out[16] tap_out[15] tap_out[14] tap_out[13] tap_out[12] tap_out[11] tap_out[10] tap_out[9] tap_out[8] tap_out[7] tap_out[6] tap_out[5] tap_out[4] tap_out[3] tap_out[2] tap_out[1] tap_out[0] tlctrl_sip__statexxnnnh[1] tlctrl_sip__statexxnnnh[0] unlock_counter__unlockcountxxnnnh[1] unlock_counter__unlockcountxxnnnh[0] vcodiv_ratio[1] vcodiv_ratio[0] vdd view_adc__dig_out[9] view_adc__dig_out[8] view_adc__dig_out[7] view_adc__dig_out[6] view_adc__dig_out[5] view_adc__dig_out[4] view_adc__dig_out[3] view_adc__dig_out[2] view_adc__dig_out[1] view_adc__dig_out[0] view_adc__done view_freq_count[14] view_freq_count[13] view_freq_count[12] view_freq_count[11] view_freq_count[10] view_freq_count[9] view_freq_count[8] view_freq_count[7] view_freq_count[6] view_freq_count[5] view_freq_count[4] view_freq_count[3] view_freq_count[2] view_freq_count[1] view_freq_count[0] view_mux__viewoutnnnnh[1] view_mux__viewoutnnnnh[0] vssx zdiv0_ratio[9] zdiv0_ratio[8] zdiv0_ratio[7] zdiv0_ratio[6] zdiv0_ratio[5] zdiv0_ratio[4] zdiv0_ratio[3] zdiv0_ratio[2] zdiv0_ratio[1] zdiv0_ratio[0] zdiv0_ratio_p5 zdiv1_ratio[9] zdiv1_ratio[8] zdiv1_ratio[7] zdiv1_ratio[6] zdiv1_ratio[5] zdiv1_ratio[4] zdiv1_ratio[3] zdiv1_ratio[2] zdiv1_ratio[1] zdiv1_ratio[0] zdiv1_ratio_p5
* .PININFO adc_ctl__startxxh:I bypassnnnnh:I fractionnnnnh[23]:I fractionnnnnh[22]:I fractionnnnnh[21]:I fractionnnnnh[20]:I fractionnnnnh[19]:I
* .PININFO fractionnnnnh[18]:I fractionnnnnh[17]:I fractionnnnnh[16]:I fractionnnnnh[15]:I fractionnnnnh[14]:I fractionnnnnh[13]:I fractionnnnnh[12]:I
* .PININFO fractionnnnnh[11]:I fractionnnnnh[10]:I fractionnnnnh[9]:I fractionnnnnh[8]:I fractionnnnnh[7]:I fractionnnnnh[6]:I fractionnnnnh[5]:I
* .PININFO fractionnnnnh[4]:I fractionnnnnh[3]:I fractionnnnnh[2]:I fractionnnnnh[1]:I fractionnnnnh[0]:I fz_cp1trim[4]:I fz_cp1trim[3]:I
* .PININFO fz_cp1trim[2]:I fz_cp1trim[1]:I fz_cp1trim[0]:I fz_cp2trim[4]:I fz_cp2trim[3]:I fz_cp2trim[2]:I fz_cp2trim[1]:I fz_cp2trim[0]:I
* .PININFO fz_cpnbias[1]:I fz_cpnbias[0]:I fz_dca_cb[1]:I fz_dca_cb[0]:I fz_dca_ctrl[5]:I fz_dca_ctrl[4]:I fz_dca_ctrl[3]:I fz_dca_ctrl[2]:I
* .PININFO fz_dca_ctrl[1]:I fz_dca_ctrl[0]:I fz_irefgen[4]:I fz_irefgen[3]:I fz_irefgen[2]:I fz_irefgen[1]:I fz_irefgen[0]:I fz_ldo_bypass:I
* .PININFO fz_ldo_extrefsel:I fz_ldo_faststart:I fz_ldo_fbtrim[3]:I fz_ldo_fbtrim[2]:I fz_ldo_fbtrim[1]:I fz_ldo_fbtrim[0]:I fz_ldo_reftrim[3]:I
* .PININFO fz_ldo_reftrim[2]:I fz_ldo_reftrim[1]:I fz_ldo_reftrim[0]:I fz_ldo_vinvoltsel[1]:I fz_ldo_vinvoltsel[0]:I fz_lockcnt[2]:I fz_lockcnt[1]:I
* .PININFO fz_lockcnt[0]:I fz_lockforce:I fz_lockstickyb:I fz_lockthresh[3]:I fz_lockthresh[2]:I fz_lockthresh[1]:I fz_lockthresh[0]:I fz_lpfclksel:I
* .PININFO fz_nopfdpwrgate:I fz_pfd_pw[2]:I fz_pfd_pw[1]:I fz_pfd_pw[0]:I fz_pfddly[1]:I fz_pfddly[0]:I fz_skadj[4]:I fz_skadj[3]:I fz_skadj[2]:I
* .PININFO fz_skadj[1]:I fz_skadj[0]:I fz_spare[4]:I fz_spare[3]:I fz_spare[2]:I fz_spare[1]:I fz_spare[0]:I fz_startup[5]:I fz_startup[4]:I
* .PININFO fz_startup[3]:I fz_startup[2]:I fz_startup[1]:I fz_startup[0]:I fz_tight_loopb:I fz_vcosel:I fz_vcotrim[10]:I fz_vcotrim[9]:I
* .PININFO fz_vcotrim[8]:I fz_vcotrim[7]:I fz_vcotrim[6]:I fz_vcotrim[5]:I fz_vcotrim[4]:I fz_vcotrim[3]:I fz_vcotrim[2]:I fz_vcotrim[1]:I
* .PININFO fz_vcotrim[0]:I idv_fub__idv_out_idvdisable_bo:I idv_fub__idv_out_idvfreqao:I idv_fub__idv_out_idvfreqbo:I idv_fub__idv_out_idvpulseo:I
* .PININFO idv_fub__idv_out_idvtclko:I idv_fub__idv_out_idvtctrlo:I idv_fub__idv_out_idvtdo:I idv_fub__idv_out_idvtreso:I iref_ctrl__irefdonexxh:I
* .PININFO ldo_enable:I lock_detector__rawlockxxnnnl:I lock_timer__locktimecntxxnnnh[11]:I lock_timer__locktimecntxxnnnh[10]:I
* .PININFO lock_timer__locktimecntxxnnnh[9]:I lock_timer__locktimecntxxnnnh[8]:I lock_timer__locktimecntxxnnnh[7]:I lock_timer__locktimecntxxnnnh[6]:I
* .PININFO lock_timer__locktimecntxxnnnh[5]:I lock_timer__locktimecntxxnnnh[4]:I lock_timer__locktimecntxxnnnh[3]:I lock_timer__locktimecntxxnnnh[2]:I
* .PININFO lock_timer__locktimecntxxnnnh[1]:I lock_timer__locktimecntxxnnnh[0]:I lockxxnnnl:I mash__halfintmxh:I mash__ratiomxh[9]:I
* .PININFO mash__ratiomxh[8]:I mash__ratiomxh[7]:I mash__ratiomxh[6]:I mash__ratiomxh[5]:I mash__ratiomxh[4]:I mash__ratiomxh[3]:I mash__ratiomxh[2]:I
* .PININFO mash__ratiomxh[1]:I mash__ratiomxh[0]:I mash_order_plus_one:I mdiv_ratio[5]:I mdiv_ratio[4]:I mdiv_ratio[3]:I mdiv_ratio[2]:I
* .PININFO mdiv_ratio[1]:I mdiv_ratio[0]:I p_abuf0:I p_abuf1:I p_abuf2:I p_abuf3:I p_abuf4:I p_abuf5:I p_abuf6:I p_abuf7:I p_abuf8:I p_abuf9:I
* .PININFO p_abuf10:I p_abuf11:I p_abuf12:I p_abuf13:I p_abuf14:I p_abuf15:I p_abuf16:I p_aps0:I p_aps1:I plldistpwrgoodnnnnh:I rationnnnh[9]:I
* .PININFO rationnnnh[8]:I rationnnnh[7]:I rationnnnh[6]:I rationnnnh[5]:I rationnnnh[4]:I rationnnnh[3]:I rationnnnh[2]:I rationnnnh[1]:I
* .PININFO rationnnnh[0]:I reg_req_ack__ratioupdackmxh:I reg_req_ack__sscprofupdackmxh:I reset_b_nnnnh:I reset_sync__reset_b_xxnnnl:I
* .PININFO ssc_cyc_to_peak_m1[8]:I ssc_cyc_to_peak_m1[7]:I ssc_cyc_to_peak_m1[6]:I ssc_cyc_to_peak_m1[5]:I ssc_cyc_to_peak_m1[4]:I
* .PININFO ssc_cyc_to_peak_m1[3]:I ssc_cyc_to_peak_m1[2]:I ssc_cyc_to_peak_m1[1]:I ssc_cyc_to_peak_m1[0]:I ssc_en:I ssc_frac_step[23]:I
* .PININFO ssc_frac_step[22]:I ssc_frac_step[21]:I ssc_frac_step[20]:I ssc_frac_step[19]:I ssc_frac_step[18]:I ssc_frac_step[17]:I ssc_frac_step[16]:I
* .PININFO ssc_frac_step[15]:I ssc_frac_step[14]:I ssc_frac_step[13]:I ssc_frac_step[12]:I ssc_frac_step[11]:I ssc_frac_step[10]:I ssc_frac_step[9]:I
* .PININFO ssc_frac_step[8]:I ssc_frac_step[7]:I ssc_frac_step[6]:I ssc_frac_step[5]:I ssc_frac_step[4]:I ssc_frac_step[3]:I ssc_frac_step[2]:I
* .PININFO ssc_frac_step[1]:I ssc_frac_step[0]:I ssc_mod_dfx__modulatorennh:I ssc_mod_dfx__triggerregxdh:I startup_gen__pfdenxxh:I tap_in[206]:I
* .PININFO tap_in[205]:I tap_in[204]:I tap_in[203]:I tap_in[202]:I tap_in[201]:I tap_in[200]:I tap_in[199]:I tap_in[198]:I tap_in[197]:I tap_in[196]:I
* .PININFO tap_in[195]:I tap_in[194]:I tap_in[193]:I tap_in[192]:I tap_in[191]:I tap_in[190]:I tap_in[189]:I tap_in[188]:I tap_in[187]:I tap_in[186]:I
* .PININFO tap_in[185]:I tap_in[184]:I tap_in[183]:I tap_in[182]:I tap_in[181]:I tap_in[180]:I tap_in[179]:I tap_in[178]:I tap_in[177]:I tap_in[176]:I
* .PININFO tap_in[175]:I tap_in[174]:I tap_in[173]:I tap_in[172]:I tap_in[171]:I tap_in[170]:I tap_in[169]:I tap_in[168]:I tap_in[167]:I tap_in[166]:I
* .PININFO tap_in[165]:I tap_in[164]:I tap_in[163]:I tap_in[162]:I tap_in[161]:I tap_in[160]:I tap_in[159]:I tap_in[158]:I tap_in[157]:I tap_in[156]:I
* .PININFO tap_in[155]:I tap_in[154]:I tap_in[153]:I tap_in[152]:I tap_in[151]:I tap_in[150]:I tap_in[149]:I tap_in[148]:I tap_in[147]:I tap_in[146]:I
* .PININFO tap_in[145]:I tap_in[144]:I tap_in[143]:I tap_in[142]:I tap_in[141]:I tap_in[140]:I tap_in[139]:I tap_in[138]:I tap_in[137]:I tap_in[136]:I
* .PININFO tap_in[135]:I tap_in[134]:I tap_in[133]:I tap_in[132]:I tap_in[131]:I tap_in[130]:I tap_in[129]:I tap_in[128]:I tap_in[127]:I tap_in[126]:I
* .PININFO tap_in[125]:I tap_in[124]:I tap_in[123]:I tap_in[122]:I tap_in[121]:I tap_in[120]:I tap_in[119]:I tap_in[118]:I tap_in[117]:I tap_in[116]:I
* .PININFO tap_in[115]:I tap_in[114]:I tap_in[113]:I tap_in[112]:I tap_in[111]:I tap_in[110]:I tap_in[109]:I tap_in[108]:I tap_in[107]:I tap_in[106]:I
* .PININFO tap_in[105]:I tap_in[104]:I tap_in[103]:I tap_in[102]:I tap_in[101]:I tap_in[100]:I tap_in[99]:I tap_in[98]:I tap_in[97]:I tap_in[96]:I
* .PININFO tap_in[95]:I tap_in[94]:I tap_in[93]:I tap_in[92]:I tap_in[91]:I tap_in[90]:I tap_in[89]:I tap_in[88]:I tap_in[87]:I tap_in[86]:I
* .PININFO tap_in[85]:I tap_in[84]:I tap_in[83]:I tap_in[82]:I tap_in[81]:I tap_in[80]:I tap_in[79]:I tap_in[78]:I tap_in[77]:I tap_in[76]:I
* .PININFO tap_in[75]:I tap_in[74]:I tap_in[73]:I tap_in[72]:I tap_in[71]:I tap_in[70]:I tap_in[69]:I tap_in[68]:I tap_in[67]:I tap_in[66]:I
* .PININFO tap_in[65]:I tap_in[64]:I tap_in[63]:I tap_in[62]:I tap_in[61]:I tap_in[60]:I tap_in[59]:I tap_in[58]:I tap_in[57]:I tap_in[56]:I
* .PININFO tap_in[55]:I tap_in[54]:I tap_in[53]:I tap_in[52]:I tap_in[51]:I tap_in[50]:I tap_in[49]:I tap_in[48]:I tap_in[47]:I tap_in[46]:I
* .PININFO tap_in[45]:I tap_in[44]:I tap_in[43]:I tap_in[42]:I tap_in[41]:I tap_in[40]:I tap_in[39]:I tap_in[38]:I tap_in[37]:I tap_in[36]:I
* .PININFO tap_in[35]:I tap_in[34]:I tap_in[33]:I tap_in[32]:I tap_in[31]:I tap_in[30]:I tap_in[29]:I tap_in[28]:I tap_in[27]:I tap_in[26]:I
* .PININFO tap_in[25]:I tap_in[24]:I tap_in[23]:I tap_in[22]:I tap_in[21]:I tap_in[20]:I tap_in[19]:I tap_in[18]:I tap_in[17]:I tap_in[16]:I
* .PININFO tap_in[15]:I tap_in[14]:I tap_in[13]:I tap_in[12]:I tap_in[11]:I tap_in[10]:I tap_in[9]:I tap_in[8]:I tap_in[7]:I tap_in[6]:I tap_in[5]:I
* .PININFO tap_in[4]:I tap_in[3]:I tap_in[2]:I tap_in[1]:I tap_in[0]:I tlctrl_sip__statexxnnnh[1]:I tlctrl_sip__statexxnnnh[0]:I
* .PININFO unlock_counter__unlockcountxxnnnh[1]:I unlock_counter__unlockcountxxnnnh[0]:I vcodiv_ratio[1]:I vcodiv_ratio[0]:I vdd:I
* .PININFO view_adc__dig_out[9]:I view_adc__dig_out[8]:I view_adc__dig_out[7]:I view_adc__dig_out[6]:I view_adc__dig_out[5]:I view_adc__dig_out[4]:I
* .PININFO view_adc__dig_out[3]:I view_adc__dig_out[2]:I view_adc__dig_out[1]:I view_adc__dig_out[0]:I view_adc__done:I view_freq_count[14]:I
* .PININFO view_freq_count[13]:I view_freq_count[12]:I view_freq_count[11]:I view_freq_count[10]:I view_freq_count[9]:I view_freq_count[8]:I
* .PININFO view_freq_count[7]:I view_freq_count[6]:I view_freq_count[5]:I view_freq_count[4]:I view_freq_count[3]:I view_freq_count[2]:I
* .PININFO view_freq_count[1]:I view_freq_count[0]:I view_mux__viewoutnnnnh[1]:I view_mux__viewoutnnnnh[0]:I vssx:I zdiv0_ratio[9]:I zdiv0_ratio[8]:I
* .PININFO zdiv0_ratio[7]:I zdiv0_ratio[6]:I zdiv0_ratio[5]:I zdiv0_ratio[4]:I zdiv0_ratio[3]:I zdiv0_ratio[2]:I zdiv0_ratio[1]:I zdiv0_ratio[0]:I
* .PININFO zdiv0_ratio_p5:I zdiv1_ratio[9]:I zdiv1_ratio[8]:I zdiv1_ratio[7]:I zdiv1_ratio[6]:I zdiv1_ratio[5]:I zdiv1_ratio[4]:I zdiv1_ratio[3]:I
* .PININFO zdiv1_ratio[2]:I zdiv1_ratio[1]:I zdiv1_ratio[0]:I zdiv1_ratio_p5:I dfx__adc_chop_en:O dfx__adc_clkdiv[1]:O dfx__adc_clkdiv[0]:O
* .PININFO dfx__adc_freeze:O dfx__adc_sel_in[2]:O dfx__adc_sel_in[1]:O dfx__adc_sel_in[0]:O dfx__adc_start:O dfx__adc_start_cnt[1]:O
* .PININFO dfx__adc_start_cnt[0]:O dfx__adc_use_vref:O dfx__bypass:O dfx__cp1_trim[4]:O dfx__cp1_trim[3]:O dfx__cp1_trim[2]:O dfx__cp1_trim[1]:O
* .PININFO dfx__cp1_trim[0]:O dfx__cp2_trim[4]:O dfx__cp2_trim[3]:O dfx__cp2_trim[2]:O dfx__cp2_trim[1]:O dfx__cp2_trim[0]:O dfx__cpnbias[1]:O
* .PININFO dfx__cpnbias[0]:O dfx__dca_cb[1]:O dfx__dca_cb[0]:O dfx__dca_ctrl[5]:O dfx__dca_ctrl[4]:O dfx__dca_ctrl[3]:O dfx__dca_ctrl[2]:O
* .PININFO dfx__dca_ctrl[1]:O dfx__dca_ctrl[0]:O dfx__disable_run_upd:O dfx__fracstepnh[23]:O dfx__fracstepnh[22]:O dfx__fracstepnh[21]:O
* .PININFO dfx__fracstepnh[20]:O dfx__fracstepnh[19]:O dfx__fracstepnh[18]:O dfx__fracstepnh[17]:O dfx__fracstepnh[16]:O dfx__fracstepnh[15]:O
* .PININFO dfx__fracstepnh[14]:O dfx__fracstepnh[13]:O dfx__fracstepnh[12]:O dfx__fracstepnh[11]:O dfx__fracstepnh[10]:O dfx__fracstepnh[9]:O
* .PININFO dfx__fracstepnh[8]:O dfx__fracstepnh[7]:O dfx__fracstepnh[6]:O dfx__fracstepnh[5]:O dfx__fracstepnh[4]:O dfx__fracstepnh[3]:O
* .PININFO dfx__fracstepnh[2]:O dfx__fracstepnh[1]:O dfx__fracstepnh[0]:O dfx__fraction[23]:O dfx__fraction[22]:O dfx__fraction[21]:O
* .PININFO dfx__fraction[20]:O dfx__fraction[19]:O dfx__fraction[18]:O dfx__fraction[17]:O dfx__fraction[16]:O dfx__fraction[15]:O dfx__fraction[14]:O
* .PININFO dfx__fraction[13]:O dfx__fraction[12]:O dfx__fraction[11]:O dfx__fraction[10]:O dfx__fraction[9]:O dfx__fraction[8]:O dfx__fraction[7]:O
* .PININFO dfx__fraction[6]:O dfx__fraction[5]:O dfx__fraction[4]:O dfx__fraction[3]:O dfx__fraction[2]:O dfx__fraction[1]:O dfx__fraction[0]:O
* .PININFO dfx__fz_irefgen_a[4]:O dfx__fz_irefgen_a[3]:O dfx__fz_irefgen_a[2]:O dfx__fz_irefgen_a[1]:O dfx__fz_irefgen_a[0]:O dfx__fz_ldo_bypass_a:O
* .PININFO dfx__fz_ldo_extrefsel_a:O dfx__fz_ldo_faststart_a:O dfx__fz_ldo_fbtrim_a[3]:O dfx__fz_ldo_fbtrim_a[2]:O dfx__fz_ldo_fbtrim_a[1]:O
* .PININFO dfx__fz_ldo_fbtrim_a[0]:O dfx__fz_ldo_reftrim_a[3]:O dfx__fz_ldo_reftrim_a[2]:O dfx__fz_ldo_reftrim_a[1]:O dfx__fz_ldo_reftrim_a[0]:O
* .PININFO dfx__fz_ldo_vinvoltsel_a[1]:O dfx__fz_ldo_vinvoltsel_a[0]:O dfx__fz_lockcnt_a[2]:O dfx__fz_lockcnt_a[1]:O dfx__fz_lockcnt_a[0]:O
* .PININFO dfx__fz_lockforce_a:O dfx__fz_lpfclksel_a:O dfx__fz_nopfdpwrgate_a:O dfx__fz_pfd_pw_a[2]:O dfx__fz_pfd_pw_a[1]:O dfx__fz_pfd_pw_a[0]:O
* .PININFO dfx__fz_pfddly_a[1]:O dfx__fz_pfddly_a[0]:O dfx__fz_spare_a[4]:O dfx__fz_spare_a[3]:O dfx__fz_spare_a[2]:O dfx__fz_spare_a[1]:O
* .PININFO dfx__fz_spare_a[0]:O dfx__fz_startup_a[5]:O dfx__fz_startup_a[4]:O dfx__fz_startup_a[3]:O dfx__fz_startup_a[2]:O dfx__fz_startup_a[1]:O
* .PININFO dfx__fz_startup_a[0]:O dfx__fz_vcosel_a:O dfx__fz_vcotrim_a[10]:O dfx__fz_vcotrim_a[9]:O dfx__fz_vcotrim_a[8]:O dfx__fz_vcotrim_a[7]:O
* .PININFO dfx__fz_vcotrim_a[6]:O dfx__fz_vcotrim_a[5]:O dfx__fz_vcotrim_a[4]:O dfx__fz_vcotrim_a[3]:O dfx__fz_vcotrim_a[2]:O dfx__fz_vcotrim_a[1]:O
* .PININFO dfx__fz_vcotrim_a[0]:O dfx__globalalignxxl:O dfx__ldo_enable_a:O dfx__lockstickyb:O dfx__lockthresh[3]:O dfx__lockthresh[2]:O
* .PININFO dfx__lockthresh[1]:O dfx__lockthresh[0]:O dfx__mash_order_plus_one:O dfx__mdiv_ratio_a[5]:O dfx__mdiv_ratio_a[4]:O dfx__mdiv_ratio_a[3]:O
* .PININFO dfx__mdiv_ratio_a[2]:O dfx__mdiv_ratio_a[1]:O dfx__mdiv_ratio_a[0]:O dfx__openloop:O dfx__pfd_residual_pw[2]:O dfx__pfd_residual_pw[1]:O
* .PININFO dfx__pfd_residual_pw[0]:O dfx__powergood:O dfx__ratio[9]:O dfx__ratio[8]:O dfx__ratio[7]:O dfx__ratio[6]:O dfx__ratio[5]:O dfx__ratio[4]:O
* .PININFO dfx__ratio[3]:O dfx__ratio[2]:O dfx__ratio[1]:O dfx__ratio[0]:O dfx__ratio_update_req:O dfx__reset_b:O dfx__skadj_ctrl[4]:O
* .PININFO dfx__skadj_ctrl[3]:O dfx__skadj_ctrl[2]:O dfx__skadj_ctrl[1]:O dfx__skadj_ctrl[0]:O dfx__ssc_cyc_to_peak_m1[8]:O
* .PININFO dfx__ssc_cyc_to_peak_m1[7]:O dfx__ssc_cyc_to_peak_m1[6]:O dfx__ssc_cyc_to_peak_m1[5]:O dfx__ssc_cyc_to_peak_m1[4]:O
* .PININFO dfx__ssc_cyc_to_peak_m1[3]:O dfx__ssc_cyc_to_peak_m1[2]:O dfx__ssc_cyc_to_peak_m1[1]:O dfx__ssc_cyc_to_peak_m1[0]:O dfx__ssc_en:O
* .PININFO dfx__ssc_prof_update_req:O dfx__sscdfxennh:O dfx__sscmodclkdivnh[1]:O dfx__sscmodclkdivnh[0]:O dfx__sscmodstepsnh[1]:O
* .PININFO dfx__sscmodstepsnh[0]:O dfx__sscmodtrignh:O dfx__start_measurement:O dfx__ta_ldo_hiz_debug:O dfx__ta_ldo_idq_debug:O dfx__ta_openloop2:O
* .PININFO dfx__ta_spare[4]:O dfx__ta_spare[3]:O dfx__ta_spare[2]:O dfx__ta_spare[1]:O dfx__ta_spare[0]:O dfx__ta_vctlrdac[3]:O dfx__ta_vctlrdac[2]:O
* .PININFO dfx__ta_vctlrdac[1]:O dfx__ta_vctlrdac[0]:O dfx__tight_loop:O dfx__tllm_en:O dfx__vcodiv_ratio_a[1]:O dfx__vcodiv_ratio_a[0]:O
* .PININFO dfx__viewanaennnnnh[1]:O dfx__viewanaennnnnh[0]:O dfx__viewdigennnnnh[1]:O dfx__viewdigennnnnh[0]:O dfx__viewselnnnnh[9]:O
* .PININFO dfx__viewselnnnnh[8]:O dfx__viewselnnnnh[7]:O dfx__viewselnnnnh[6]:O dfx__viewselnnnnh[5]:O dfx__viewselnnnnh[4]:O dfx__viewselnnnnh[3]:O
* .PININFO dfx__viewselnnnnh[2]:O dfx__viewselnnnnh[1]:O dfx__viewselnnnnh[0]:O dfx__zdiv0_ratio_a[9]:O dfx__zdiv0_ratio_a[8]:O
* .PININFO dfx__zdiv0_ratio_a[7]:O dfx__zdiv0_ratio_a[6]:O dfx__zdiv0_ratio_a[5]:O dfx__zdiv0_ratio_a[4]:O dfx__zdiv0_ratio_a[3]:O
* .PININFO dfx__zdiv0_ratio_a[2]:O dfx__zdiv0_ratio_a[1]:O dfx__zdiv0_ratio_a[0]:O dfx__zdiv0_ratio_p5_a:O dfx__zdiv1_ratio_a[9]:O
* .PININFO dfx__zdiv1_ratio_a[8]:O dfx__zdiv1_ratio_a[7]:O dfx__zdiv1_ratio_a[6]:O dfx__zdiv1_ratio_a[5]:O dfx__zdiv1_ratio_a[4]:O
* .PININFO dfx__zdiv1_ratio_a[3]:O dfx__zdiv1_ratio_a[2]:O dfx__zdiv1_ratio_a[1]:O dfx__zdiv1_ratio_a[0]:O dfx__zdiv1_ratio_p5_a:O dfx_out[11]:O
* .PININFO dfx_out[10]:O dfx_out[9]:O dfx_out[8]:O dfx_out[7]:O dfx_out[6]:O dfx_out[5]:O dfx_out[4]:O dfx_out[3]:O dfx_out[2]:O dfx_out[1]:O
* .PININFO dfx_out[0]:O tap_out[61]:O tap_out[60]:O tap_out[59]:O tap_out[58]:O tap_out[57]:O tap_out[56]:O tap_out[55]:O tap_out[54]:O tap_out[53]:O
* .PININFO tap_out[52]:O tap_out[51]:O tap_out[50]:O tap_out[49]:O tap_out[48]:O tap_out[47]:O tap_out[46]:O tap_out[45]:O tap_out[44]:O tap_out[43]:O
* .PININFO tap_out[42]:O tap_out[41]:O tap_out[40]:O tap_out[39]:O tap_out[38]:O tap_out[37]:O tap_out[36]:O tap_out[35]:O tap_out[34]:O tap_out[33]:O
* .PININFO tap_out[32]:O tap_out[31]:O tap_out[30]:O tap_out[29]:O tap_out[28]:O tap_out[27]:O tap_out[26]:O tap_out[25]:O tap_out[24]:O tap_out[23]:O
* .PININFO tap_out[22]:O tap_out[21]:O tap_out[20]:O tap_out[19]:O tap_out[18]:O tap_out[17]:O tap_out[16]:O tap_out[15]:O tap_out[14]:O tap_out[13]:O
* .PININFO tap_out[12]:O tap_out[11]:O tap_out[10]:O tap_out[9]:O tap_out[8]:O tap_out[7]:O tap_out[6]:O tap_out[5]:O tap_out[4]:O tap_out[3]:O
* .PININFO tap_out[2]:O tap_out[1]:O tap_out[0]:O
Xu303 p_abuf15 tap_in[166] fractionnnnnh[1] p_abuf6 dfx__fraction[1] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu302 p_abuf15 tap_in[165] fractionnnnnh[0] p_abuf6 dfx__fraction[0] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu304 p_abuf15 tap_in[167] fractionnnnnh[2] p_abuf6 dfx__fraction[2] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu305 p_abuf15 tap_in[168] fractionnnnnh[3] p_abuf6 dfx__fraction[3] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu306 p_abuf15 tap_in[169] fractionnnnnh[4] p_abuf6 dfx__fraction[4] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu307 p_abuf15 tap_in[170] fractionnnnnh[5] p_abuf6 dfx__fraction[5] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu308 p_abuf15 tap_in[171] fractionnnnnh[6] p_abuf6 dfx__fraction[6] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu309 p_abuf15 tap_in[172] fractionnnnnh[7] p_abuf6 dfx__fraction[7] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu311 p_abuf15 tap_in[174] fractionnnnnh[9] p_abuf6 dfx__fraction[9] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu315 p_abuf15 tap_in[178] fractionnnnnh[13] p_abuf6 dfx__fraction[13] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu316 p_abuf15 tap_in[179] fractionnnnnh[14] p_abuf6 dfx__fraction[14] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu319 p_abuf15 tap_in[182] fractionnnnnh[17] p_abuf6 dfx__fraction[17] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu320 p_abuf15 tap_in[183] fractionnnnnh[18] p_abuf6 dfx__fraction[18] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu321 p_abuf15 tap_in[184] fractionnnnnh[19] p_abuf6 dfx__fraction[19] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu322 p_abuf15 tap_in[185] fractionnnnnh[20] p_abuf6 dfx__fraction[20] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu323 p_abuf15 tap_in[186] fractionnnnnh[21] p_abuf6 dfx__fraction[21] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu324 p_abuf15 tap_in[187] fractionnnnnh[22] p_abuf6 dfx__fraction[22] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu290 p_abuf15 tap_in[188] fractionnnnnh[23] p_abuf6 dfx__fraction[23] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu310 p_aps0 tap_in[173] fractionnnnnh[8] tap_in[189] dfx__fraction[8] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu312 p_aps0 tap_in[175] fractionnnnnh[10] tap_in[189] dfx__fraction[10] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu313 p_aps0 tap_in[176] fractionnnnnh[11] tap_in[189] dfx__fraction[11] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu314 p_aps0 tap_in[177] fractionnnnnh[12] tap_in[189] dfx__fraction[12] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu317 p_aps0 tap_in[180] fractionnnnnh[15] tap_in[189] dfx__fraction[15] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu318 p_aps0 tap_in[181] fractionnnnnh[16] tap_in[189] dfx__fraction[16] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu277 p_abuf14 tap_in[57] fz_vcotrim[0] p_abuf3 dfx__fz_vcotrim_a[0] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu276 p_abuf14 tap_in[58] fz_vcotrim[1] p_abuf3 dfx__fz_vcotrim_a[1] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu275 p_abuf14 tap_in[59] fz_vcotrim[2] p_abuf3 dfx__fz_vcotrim_a[2] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu271 p_abuf14 tap_in[63] fz_vcotrim[6] p_abuf3 dfx__fz_vcotrim_a[6] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu270 p_abuf14 tap_in[64] fz_vcotrim[7] p_abuf3 dfx__fz_vcotrim_a[7] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu269 p_abuf14 tap_in[65] fz_vcotrim[8] p_abuf3 dfx__fz_vcotrim_a[8] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu267 p_abuf14 tap_in[66] fz_vcotrim[9] p_abuf3 dfx__fz_vcotrim_a[9] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu286 p_abuf8 tap_in[111] fz_lockcnt[2] p_abuf0 dfx__fz_lockcnt_a[2] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu284 p_abuf8 tap_in[109] fz_lockcnt[0] p_abuf0 dfx__fz_lockcnt_a[0] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu292 tap_in[200] tap_in[190] rationnnnh[0] n201 dfx__ratio[0] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu293 tap_in[200] tap_in[191] rationnnnh[1] n201 dfx__ratio[1] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu294 tap_in[200] tap_in[192] rationnnnh[2] n201 dfx__ratio[2] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu295 tap_in[200] tap_in[193] rationnnnh[3] n201 dfx__ratio[3] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu296 tap_in[200] tap_in[194] rationnnnh[4] n201 dfx__ratio[4] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu297 tap_in[200] tap_in[195] rationnnnh[5] n201 dfx__ratio[5] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu298 tap_in[200] tap_in[196] rationnnnh[6] n201 dfx__ratio[6] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu299 tap_in[200] tap_in[197] rationnnnh[7] n201 dfx__ratio[7] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu300 tap_in[200] tap_in[198] rationnnnh[8] n201 dfx__ratio[8] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu325 tap_in[200] tap_in[199] rationnnnh[9] n201 dfx__ratio[9] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu57 tap_in[161] dfx__adc_start_cnt[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu58 tap_in[162] dfx__adc_start_cnt[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu343 reset_sync__reset_b_xxnnnl tap_out[61] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu31 tlctrl_sip__statexxnnnh[1] tap_out[16] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu30 tlctrl_sip__statexxnnnh[0] tap_out[15] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu81 tap_in[160] dfx__adc_clkdiv[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu80 tap_in[159] dfx__adc_clkdiv[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu54 tap_in[134] dfx__sscmodclkdivnh[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu53 tap_in[133] dfx__sscmodclkdivnh[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu47 unlock_counter__unlockcountxxnnnh[1] tap_out[57] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu46 unlock_counter__unlockcountxxnnnh[0] tap_out[56] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu2 tap_in[4] dfx__ta_openloop2 vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu338 adc_ctl__startxxh tap_out[20] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu72 startup_gen__pfdenxxh tap_out[58] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu26 view_freq_count[11] tap_out[11] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu22 view_freq_count[7] tap_out[7] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu24 view_freq_count[9] tap_out[9] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu146 mash__halfintmxh tap_out[33] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu29 view_freq_count[14] tap_out[14] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu28 view_freq_count[13] tap_out[13] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu25 view_freq_count[10] tap_out[10] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu23 view_freq_count[8] tap_out[8] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu21 view_freq_count[6] tap_out[6] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu17 view_freq_count[2] tap_out[2] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu20 view_freq_count[5] tap_out[5] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu19 view_freq_count[4] tap_out[4] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu18 view_freq_count[3] tap_out[3] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu27 view_freq_count[12] tap_out[12] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu15 view_freq_count[0] tap_out[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu16 view_freq_count[1] tap_out[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu132 tap_in[10] dfx__ta_ldo_idq_debug vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu131 tap_in[11] dfx__ta_ldo_hiz_debug vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu130 view_adc__done tap_out[19] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu115 ssc_en dfx__ssc_en vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu114 ssc_frac_step[23] dfx__fracstepnh[23] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu113 ssc_frac_step[22] dfx__fracstepnh[22] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu112 ssc_frac_step[21] dfx__fracstepnh[21] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu111 ssc_frac_step[20] dfx__fracstepnh[20] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu110 ssc_frac_step[19] dfx__fracstepnh[19] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu109 ssc_frac_step[18] dfx__fracstepnh[18] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu108 ssc_frac_step[17] dfx__fracstepnh[17] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu107 ssc_frac_step[16] dfx__fracstepnh[16] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu106 ssc_frac_step[15] dfx__fracstepnh[15] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu105 ssc_frac_step[14] dfx__fracstepnh[14] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu104 ssc_frac_step[13] dfx__fracstepnh[13] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu103 ssc_frac_step[12] dfx__fracstepnh[12] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu102 ssc_frac_step[11] dfx__fracstepnh[11] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu101 ssc_frac_step[10] dfx__fracstepnh[10] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu100 ssc_frac_step[9] dfx__fracstepnh[9] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu99 ssc_frac_step[8] dfx__fracstepnh[8] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu98 ssc_frac_step[7] dfx__fracstepnh[7] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu97 ssc_frac_step[6] dfx__fracstepnh[6] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu96 ssc_frac_step[5] dfx__fracstepnh[5] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu95 ssc_frac_step[4] dfx__fracstepnh[4] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu94 ssc_frac_step[3] dfx__fracstepnh[3] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu93 ssc_frac_step[2] dfx__fracstepnh[2] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu92 ssc_frac_step[1] dfx__fracstepnh[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu91 ssc_frac_step[0] dfx__fracstepnh[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu79 tap_in[158] dfx__adc_freeze vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu78 tap_in[157] dfx__adc_chop_en vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu77 tap_in[156] dfx__adc_use_vref vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu73 lock_detector__rawlockxxnnnl tap_out[31] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu59 tap_in[163] dfx__adc_start vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu56 tap_in[138] dfx__sscdfxennh vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu55 tap_in[137] dfx__sscmodtrignh vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu52 tap_in[12] dfx__start_measurement vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu33 ssc_mod_dfx__modulatorennh tap_out[18] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu32 ssc_mod_dfx__triggerregxdh tap_out[17] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu3 tap_in[164] dfx__openloop vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu138 mash__ratiomxh[7] tap_out[41] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu139 mash__ratiomxh[6] tap_out[40] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu140 mash__ratiomxh[5] tap_out[39] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu141 mash__ratiomxh[4] tap_out[38] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu142 mash__ratiomxh[3] tap_out[37] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu143 mash__ratiomxh[2] tap_out[36] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu144 mash__ratiomxh[1] tap_out[35] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu145 mash__ratiomxh[0] tap_out[34] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu128 mash__ratiomxh[9] tap_out[43] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu137 mash__ratiomxh[8] tap_out[42] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu151 tap_in[5] dfx__ta_spare[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu150 tap_in[6] dfx__ta_spare[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu149 tap_in[7] dfx__ta_spare[2] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu148 tap_in[8] dfx__ta_spare[3] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu147 tap_in[9] dfx__ta_spare[4] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu129 view_adc__dig_out[0] tap_out[21] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu90 view_adc__dig_out[9] tap_out[30] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu89 view_adc__dig_out[8] tap_out[29] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu88 view_adc__dig_out[7] tap_out[28] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu87 view_adc__dig_out[6] tap_out[27] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu86 view_adc__dig_out[5] tap_out[26] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu85 view_adc__dig_out[4] tap_out[25] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu84 view_adc__dig_out[3] tap_out[24] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu83 view_adc__dig_out[2] tap_out[23] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu82 view_adc__dig_out[1] tap_out[22] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu76 tap_in[155] dfx__adc_sel_in[2] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu75 tap_in[154] dfx__adc_sel_in[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu74 tap_in[153] dfx__adc_sel_in[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu71 tap_in[143] dfx__viewselnnnnh[4] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu70 tap_in[142] dfx__viewselnnnnh[3] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu69 tap_in[141] dfx__viewselnnnnh[2] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu68 tap_in[140] dfx__viewselnnnnh[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu67 tap_in[139] dfx__viewselnnnnh[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu66 tap_in[148] dfx__viewselnnnnh[9] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu65 tap_in[147] dfx__viewselnnnnh[8] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu64 tap_in[146] dfx__viewselnnnnh[7] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu63 tap_in[145] dfx__viewselnnnnh[6] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu62 tap_in[144] dfx__viewselnnnnh[5] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu51 tap_in[3] dfx__ta_vctlrdac[3] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu50 tap_in[2] dfx__ta_vctlrdac[2] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu49 tap_in[1] dfx__ta_vctlrdac[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu48 tap_in[0] dfx__ta_vctlrdac[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu5 tap_in[136] dfx__sscmodstepsnh[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu4 tap_in[135] dfx__sscmodstepsnh[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu45 lock_timer__locktimecntxxnnnh[11] tap_out[55] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu44 lock_timer__locktimecntxxnnnh[10] tap_out[54] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu43 lock_timer__locktimecntxxnnnh[9] tap_out[53] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu42 lock_timer__locktimecntxxnnnh[8] tap_out[52] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu41 lock_timer__locktimecntxxnnnh[7] tap_out[51] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu40 lock_timer__locktimecntxxnnnh[6] tap_out[50] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu39 lock_timer__locktimecntxxnnnh[5] tap_out[49] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu38 lock_timer__locktimecntxxnnnh[4] tap_out[48] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu37 lock_timer__locktimecntxxnnnh[3] tap_out[47] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu36 lock_timer__locktimecntxxnnnh[2] tap_out[46] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu35 lock_timer__locktimecntxxnnnh[1] tap_out[45] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu34 lock_timer__locktimecntxxnnnh[0] tap_out[44] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu14 ssc_cyc_to_peak_m1[0] dfx__ssc_cyc_to_peak_m1[0] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu13 ssc_cyc_to_peak_m1[8] dfx__ssc_cyc_to_peak_m1[8] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu12 ssc_cyc_to_peak_m1[7] dfx__ssc_cyc_to_peak_m1[7] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu11 ssc_cyc_to_peak_m1[6] dfx__ssc_cyc_to_peak_m1[6] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu10 ssc_cyc_to_peak_m1[5] dfx__ssc_cyc_to_peak_m1[5] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu9 ssc_cyc_to_peak_m1[4] dfx__ssc_cyc_to_peak_m1[4] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu8 ssc_cyc_to_peak_m1[3] dfx__ssc_cyc_to_peak_m1[3] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu7 ssc_cyc_to_peak_m1[2] dfx__ssc_cyc_to_peak_m1[2] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu6 ssc_cyc_to_peak_m1[1] dfx__ssc_cyc_to_peak_m1[1] vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu224 p_abuf13 tap_in[93] fz_cpnbias[1] p_abuf0 dfx__cpnbias[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu225 p_abuf16 tap_in[92] fz_cpnbias[0] p_abuf2 dfx__cpnbias[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu265 p_abuf14 tap_in[68] fz_vcosel p_abuf3 dfx__fz_vcosel_a vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu174 p_abuf8 tap_in[53] fz_ldo_bypass p_abuf0 dfx__fz_ldo_bypass_a vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu175 p_abuf8 tap_in[52] fz_ldo_extrefsel p_abuf0 dfx__fz_ldo_extrefsel_a vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu282 p_abuf12 tap_in[75] fz_spare[0] p_abuf4 dfx__fz_spare_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu283 p_abuf12 tap_in[76] fz_spare[1] p_abuf4 dfx__fz_spare_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu264 p_abuf11 tap_in[131] fz_tight_loopb p_abuf1 dfx__tight_loop vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu246 p_abuf11 tap_in[86] fz_nopfdpwrgate p_abuf1 dfx__fz_nopfdpwrgate_a vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu245 p_abuf11 tap_in[82] fz_lpfclksel p_abuf1 dfx__fz_lpfclksel_a vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu212 p_aps1 tap_in[13] zdiv1_ratio_p5 tap_in[132] dfx__zdiv1_ratio_p5_a vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu255 p_abuf10 tap_in[77] fz_spare[2] p_abuf1 dfx__fz_spare_a[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu254 p_abuf11 tap_in[79] fz_spare[4] p_abuf1 dfx__fz_spare_a[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu171 p_abuf8 tap_in[55] fz_ldo_vinvoltsel[1] p_abuf0 dfx__fz_ldo_vinvoltsel_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu172 p_abuf8 tap_in[54] fz_ldo_vinvoltsel[0] p_abuf0 dfx__fz_ldo_vinvoltsel_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu180 p_abuf13 tap_in[36] vcodiv_ratio[1] p_abuf0 dfx__vcodiv_ratio_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu181 p_abuf13 tap_in[35] vcodiv_ratio[0] p_abuf0 dfx__vcodiv_ratio_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu248 p_abuf10 tap_in[80] fz_pfddly[0] p_abuf1 dfx__fz_pfddly_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu247 p_abuf10 tap_in[81] fz_pfddly[1] p_abuf1 dfx__fz_pfddly_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu227 p_aps1 tap_in[101] fz_dca_cb[0] tap_in[132] dfx__dca_cb[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu226 p_aps1 tap_in[102] fz_dca_cb[1] tap_in[132] dfx__dca_cb[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu178 p_abuf8 tap_in[37] mdiv_ratio[0] p_abuf0 dfx__mdiv_ratio_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu273 p_abuf14 tap_in[61] fz_vcotrim[4] p_abuf3 dfx__fz_vcotrim_a[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu274 p_abuf14 tap_in[60] fz_vcotrim[3] p_abuf3 dfx__fz_vcotrim_a[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu272 p_abuf14 tap_in[62] fz_vcotrim[5] p_abuf3 dfx__fz_vcotrim_a[5] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu266 p_abuf14 tap_in[67] fz_vcotrim[10] p_abuf3 dfx__fz_vcotrim_a[10] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu243 p_abuf8 tap_in[106] fz_lockthresh[1] p_abuf0 dfx__lockthresh[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu244 p_abuf8 tap_in[105] fz_lockthresh[0] p_abuf0 dfx__lockthresh[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu242 p_abuf8 tap_in[107] fz_lockthresh[2] p_abuf0 dfx__lockthresh[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu241 p_abuf12 tap_in[108] fz_lockthresh[3] p_abuf4 dfx__lockthresh[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu326 p_abuf11 tap_in[38] mdiv_ratio[1] p_abuf1 dfx__mdiv_ratio_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu327 p_abuf11 tap_in[39] mdiv_ratio[2] p_abuf1 dfx__mdiv_ratio_a[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu328 p_abuf11 tap_in[40] mdiv_ratio[3] p_abuf1 dfx__mdiv_ratio_a[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu329 p_abuf11 tap_in[41] mdiv_ratio[4] p_abuf1 dfx__mdiv_ratio_a[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu330 p_abuf11 tap_in[42] mdiv_ratio[5] p_abuf1 dfx__mdiv_ratio_a[5] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu236 p_abuf11 tap_in[91] fz_irefgen[4] p_abuf1 dfx__fz_irefgen_a[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu240 p_abuf11 tap_in[87] fz_irefgen[0] p_abuf1 dfx__fz_irefgen_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu239 p_abuf11 tap_in[88] fz_irefgen[1] p_abuf1 dfx__fz_irefgen_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu238 p_abuf11 tap_in[89] fz_irefgen[2] p_abuf1 dfx__fz_irefgen_a[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu237 p_abuf11 tap_in[90] fz_irefgen[3] p_abuf1 dfx__fz_irefgen_a[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu231 p_aps1 tap_in[96] fz_dca_ctrl[2] tap_in[132] dfx__dca_ctrl[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu233 p_aps1 tap_in[94] fz_dca_ctrl[0] tap_in[132] dfx__dca_ctrl[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu232 p_aps1 tap_in[95] fz_dca_ctrl[1] tap_in[132] dfx__dca_ctrl[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu230 p_aps1 tap_in[97] fz_dca_ctrl[3] tap_in[132] dfx__dca_ctrl[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu229 p_aps1 tap_in[98] fz_dca_ctrl[4] tap_in[132] dfx__dca_ctrl[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu228 p_aps1 tap_in[99] fz_dca_ctrl[5] tap_in[132] dfx__dca_ctrl[5] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu191 p_abuf8 tap_in[50] fz_ldo_fbtrim[3] p_abuf0 dfx__fz_ldo_fbtrim_a[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu189 p_abuf8 tap_in[48] fz_ldo_fbtrim[1] p_abuf0 dfx__fz_ldo_fbtrim_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu188 p_abuf8 tap_in[49] fz_ldo_fbtrim[2] p_abuf0 dfx__fz_ldo_fbtrim_a[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu194 p_abuf13 tap_in[47] fz_ldo_fbtrim[0] p_abuf0 dfx__fz_ldo_fbtrim_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu200 p_abuf11 tap_in[43] fz_ldo_reftrim[0] p_abuf1 dfx__fz_ldo_reftrim_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu263 p_abuf14 tap_in[69] fz_startup[0] p_abuf3 dfx__fz_startup_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu262 p_abuf14 tap_in[70] fz_startup[1] p_abuf3 dfx__fz_startup_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu261 p_abuf14 tap_in[71] fz_startup[2] p_abuf3 dfx__fz_startup_a[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu259 p_abuf14 tap_in[73] fz_startup[4] p_abuf3 dfx__fz_startup_a[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu260 p_abuf12 tap_in[72] fz_startup[3] p_abuf3 dfx__fz_startup_a[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu258 p_abuf12 tap_in[74] fz_startup[5] p_abuf4 dfx__fz_startup_a[5] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu253 p_abuf12 tap_in[112] fz_skadj[0] p_abuf4 dfx__skadj_ctrl[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu252 p_abuf12 tap_in[113] fz_skadj[1] p_abuf4 dfx__skadj_ctrl[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu251 p_abuf12 tap_in[114] fz_skadj[2] p_abuf4 dfx__skadj_ctrl[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu250 p_abuf12 tap_in[115] fz_skadj[3] p_abuf4 dfx__skadj_ctrl[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu249 p_abuf12 tap_in[116] fz_skadj[4] p_abuf4 dfx__skadj_ctrl[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu211 p_aps1 tap_in[14] zdiv1_ratio[0] tap_in[132] dfx__zdiv1_ratio_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu210 p_aps1 tap_in[15] zdiv1_ratio[1] tap_in[132] dfx__zdiv1_ratio_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu209 p_aps1 tap_in[16] zdiv1_ratio[2] tap_in[132] dfx__zdiv1_ratio_a[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu208 p_aps1 tap_in[17] zdiv1_ratio[3] tap_in[132] dfx__zdiv1_ratio_a[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu207 p_aps1 tap_in[18] zdiv1_ratio[4] tap_in[132] dfx__zdiv1_ratio_a[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu206 p_aps1 tap_in[19] zdiv1_ratio[5] tap_in[132] dfx__zdiv1_ratio_a[5] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu205 p_abuf8 tap_in[20] zdiv1_ratio[6] tap_in[132] dfx__zdiv1_ratio_a[6] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu199 p_abuf8 tap_in[23] zdiv1_ratio[9] tap_in[132] dfx__zdiv1_ratio_a[9] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu201 p_aps1 tap_in[22] zdiv1_ratio[8] tap_in[132] dfx__zdiv1_ratio_a[8] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu204 p_abuf9 tap_in[21] zdiv1_ratio[7] tap_in[132] dfx__zdiv1_ratio_a[7] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu182 p_aps1 tap_in[34] zdiv0_ratio[9] p_abuf7 dfx__zdiv0_ratio_a[9] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu185 p_abuf9 tap_in[32] zdiv0_ratio[7] tap_in[132] dfx__zdiv0_ratio_a[7] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu203 p_abuf9 tap_in[28] zdiv0_ratio[3] p_abuf5 dfx__zdiv0_ratio_a[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu202 p_abuf9 tap_in[29] zdiv0_ratio[4] p_abuf5 dfx__zdiv0_ratio_a[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu197 p_abuf9 tap_in[24] zdiv0_ratio_p5 p_abuf5 dfx__zdiv0_ratio_p5_a vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu193 p_abuf9 tap_in[25] zdiv0_ratio[0] p_abuf5 dfx__zdiv0_ratio_a[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu192 p_abuf9 tap_in[26] zdiv0_ratio[1] p_abuf5 dfx__zdiv0_ratio_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu190 p_abuf9 tap_in[27] zdiv0_ratio[2] p_abuf5 dfx__zdiv0_ratio_a[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu187 p_abuf9 tap_in[30] zdiv0_ratio[5] p_abuf5 dfx__zdiv0_ratio_a[5] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu186 p_abuf9 tap_in[31] zdiv0_ratio[6] p_abuf5 dfx__zdiv0_ratio_a[6] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu184 p_abuf9 tap_in[33] zdiv0_ratio[8] p_abuf5 dfx__zdiv0_ratio_a[8] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu195 p_abuf16 tap_in[46] fz_ldo_reftrim[3] p_abuf2 dfx__fz_ldo_reftrim_a[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu168 p_abuf16 tap_in[45] fz_ldo_reftrim[2] p_abuf2 dfx__fz_ldo_reftrim_a[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu165 p_abuf16 tap_in[44] fz_ldo_reftrim[1] p_abuf2 dfx__fz_ldo_reftrim_a[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu220 p_abuf16 tap_in[120] fz_cp2trim[3] p_abuf2 dfx__cp2_trim[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu219 p_abuf16 tap_in[121] fz_cp2trim[4] p_abuf2 dfx__cp2_trim[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu222 p_abuf16 tap_in[118] fz_cp2trim[1] p_abuf2 dfx__cp2_trim[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu221 p_abuf13 tap_in[119] fz_cp2trim[2] p_abuf2 dfx__cp2_trim[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu223 p_abuf16 tap_in[117] fz_cp2trim[0] p_abuf2 dfx__cp2_trim[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu217 p_abuf16 tap_in[123] fz_cp1trim[1] p_abuf2 dfx__cp1_trim[1] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu214 p_abuf16 tap_in[125] fz_cp1trim[3] p_abuf2 dfx__cp1_trim[3] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu213 p_abuf16 tap_in[126] fz_cp1trim[4] p_abuf2 dfx__cp1_trim[4] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu215 p_abuf13 tap_in[124] fz_cp1trim[2] p_abuf2 dfx__cp1_trim[2] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu218 p_abuf13 tap_in[122] fz_cp1trim[0] p_abuf2 dfx__cp1_trim[0] vdd vssx ringpll__b15ao0022an1n04x5 m=1
Xu285 p_abuf8 tap_in[110] fz_lockcnt[1] tap_in[132] dfx__fz_lockcnt_a[1] vdd vssx ringpll__b15ao0022ah1n02x5 m=1
Xu287 fz_spare[3] p_abuf4 n26 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu335 fz_pfd_pw[0] p_abuf4 n27 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu333 fz_pfd_pw[1] p_abuf4 n28 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu331 fz_pfd_pw[2] p_abuf4 n29 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu288 n26 p_abuf11 tap_in[100] dfx__tllm_en vdd vssx ringpll__b15aob012an1n04x5 m=1
Xu337 n26 p_abuf10 tap_in[78] dfx__fz_spare_a[3] vdd vssx ringpll__b15aob012an1n04x5 m=1
Xu336 n27 p_abuf10 tap_in[83] dfx__fz_pfd_pw_a[0] vdd vssx ringpll__b15aob012an1n04x5 m=1
Xu334 n28 p_abuf11 tap_in[84] dfx__fz_pfd_pw_a[1] vdd vssx ringpll__b15aob012an1n04x5 m=1
Xu332 n29 p_abuf10 tap_in[85] dfx__fz_pfd_pw_a[2] vdd vssx ringpll__b15aob012an1n04x5 m=1
Xu133 plldistpwrgoodnnnnh n1 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu160 bypassnnnnh n4 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu235 tap_in[200] n201 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu159 n3 dfx__reset_b vdd vssx ringpll__b15inv000al1n05x5 m=1
Xu156 tap_in[206] reset_b_nnnnh tap_in[206] tap_in[205] n3 vdd vssx ringpll__b15aboi22an1n08x5 m=1
Xu135 tap_out[60] dfx__powergood vdd vssx ringpll__b15bfn000al1n03x5 m=1
Xu281 tap_in[151] tap_in[149] dfx__viewanaennnnnh[0] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu280 tap_in[152] tap_in[150] dfx__viewanaennnnnh[1] vdd vssx ringpll__b15and002al1n03x5 m=1
Xplace_ftb_1__306 lockxxnnnl net_aps_307 vdd vssx ringpll__b15inv000al1n02x5 m=1
Xplace_ftb_12__307 net_aps_307 tap_out[32] vdd vssx ringpll__b15inv000an1n02x5 m=1
Xu167 reset_sync__reset_b_xxnnnl tap_in[51] p_abuf10 fz_ldo_faststart p_abuf1 dfx__fz_ldo_faststart_a vdd vssx ringpll__b15aoi122al1n04x5 m=1
Xu279 tap_in[151] tap_in[149] dfx__viewdigennnnnh[0] vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu278 tap_in[152] tap_in[150] dfx__viewdigennnnnh[1] vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu134 tap_in[204] tap_in[203] tap_in[204] n1 tap_out[60] vdd vssx ringpll__b15naoai3en1n04x5 m=1
Xu161 tap_in[202] tap_in[201] tap_in[202] n4 dfx__bypass vdd vssx ringpll__b15naoai3en1n04x5 m=1
Xu157 p_abuf14 tap_in[56] ldo_enable p_abuf4 n2 vdd vssx ringpll__b15aoi022an1n04x3 m=1
Xu158 n3 n2 dfx__ldo_enable_a vdd vssx ringpll__b15nandp2al1n04x5 m=1
Xu173 tap_in[130] fz_lockforce dfx__fz_lockforce_a p_abuf16 vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu301 p_abuf13 tap_in[103] mash_order_plus_one p_abuf2 dfx__mash_order_plus_one vdd vssx ringpll__b15ao0022ah1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ratio_async_mux
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ratio_async_mux reset_sync__bypassxxnnnl lockxxnnnl dfx__ratio[9] dfx__ratio[8] dfx__ratio[7] dfx__ratio[6] dfx__ratio[5] dfx__ratio[4] dfx__ratio[3] dfx__ratio[2] dfx__ratio[1] dfx__ratio[0] ssc__ratiomxh[9] ssc__ratiomxh[8] ssc__ratiomxh[7] ssc__ratiomxh[6] ssc__ratiomxh[5] ssc__ratiomxh[4] ssc__ratiomxh[3] ssc__ratiomxh[2] ssc__ratiomxh[1] ssc__ratiomxh[0] dfx__fraction[23] dfx__fraction[22] dfx__fraction[21] dfx__fraction[20] dfx__fraction[19] dfx__fraction[18] dfx__fraction[17] dfx__fraction[16] dfx__fraction[15] dfx__fraction[14] dfx__fraction[13] dfx__fraction[12] dfx__fraction[11] dfx__fraction[10] dfx__fraction[9] dfx__fraction[8] dfx__fraction[7] dfx__fraction[6] dfx__fraction[5] dfx__fraction[4] dfx__fraction[3] dfx__fraction[2] dfx__fraction[1] dfx__fraction[0] ssc__fractionmxh[23] ssc__fractionmxh[22] ssc__fractionmxh[21] ssc__fractionmxh[20] ssc__fractionmxh[19] ssc__fractionmxh[18] ssc__fractionmxh[17] ssc__fractionmxh[16] ssc__fractionmxh[15] ssc__fractionmxh[14] ssc__fractionmxh[13] ssc__fractionmxh[12] ssc__fractionmxh[11] ssc__fractionmxh[10] ssc__fractionmxh[9] ssc__fractionmxh[8] ssc__fractionmxh[7] ssc__fractionmxh[6] ssc__fractionmxh[5] ssc__fractionmxh[4] ssc__fractionmxh[3] ssc__fractionmxh[2] ssc__fractionmxh[1] ssc__fractionmxh[0] mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] ratio_async_mux__ratiomxh[9] ratio_async_mux__ratiomxh[8] ratio_async_mux__ratiomxh[7] ratio_async_mux__ratiomxh[6] ratio_async_mux__ratiomxh[5] ratio_async_mux__ratiomxh[4] ratio_async_mux__ratiomxh[3] ratio_async_mux__ratiomxh[2] ratio_async_mux__ratiomxh[1] ratio_async_mux__ratiomxh[0] ratio_async_mux__fractionmxh[23] ratio_async_mux__fractionmxh[22] ratio_async_mux__fractionmxh[21] ratio_async_mux__fractionmxh[20] ratio_async_mux__fractionmxh[19] ratio_async_mux__fractionmxh[18] ratio_async_mux__fractionmxh[17] ratio_async_mux__fractionmxh[16] ratio_async_mux__fractionmxh[15] ratio_async_mux__fractionmxh[14] ratio_async_mux__fractionmxh[13] ratio_async_mux__fractionmxh[12] ratio_async_mux__fractionmxh[11] ratio_async_mux__fractionmxh[10] ratio_async_mux__fractionmxh[9] ratio_async_mux__fractionmxh[8] ratio_async_mux__fractionmxh[7] ratio_async_mux__fractionmxh[6] ratio_async_mux__fractionmxh[5] ratio_async_mux__fractionmxh[4] ratio_async_mux__fractionmxh[3] ratio_async_mux__fractionmxh[2] ratio_async_mux__fractionmxh[1] ratio_async_mux__fractionmxh[0] vdd vssx
* .PININFO dfx__fraction[23]:I dfx__fraction[22]:I dfx__fraction[21]:I dfx__fraction[20]:I dfx__fraction[19]:I dfx__fraction[18]:I dfx__fraction[17]:I
* .PININFO dfx__fraction[16]:I dfx__fraction[15]:I dfx__fraction[14]:I dfx__fraction[13]:I dfx__fraction[12]:I dfx__fraction[11]:I dfx__fraction[10]:I
* .PININFO dfx__fraction[9]:I dfx__fraction[8]:I dfx__fraction[7]:I dfx__fraction[6]:I dfx__fraction[5]:I dfx__fraction[4]:I dfx__fraction[3]:I
* .PININFO dfx__fraction[2]:I dfx__fraction[1]:I dfx__fraction[0]:I dfx__ratio[9]:I dfx__ratio[8]:I dfx__ratio[7]:I dfx__ratio[6]:I dfx__ratio[5]:I
* .PININFO dfx__ratio[4]:I dfx__ratio[3]:I dfx__ratio[2]:I dfx__ratio[1]:I dfx__ratio[0]:I lockxxnnnl:I mdiv_ratio[5]:I mdiv_ratio[4]:I
* .PININFO mdiv_ratio[3]:I mdiv_ratio[2]:I mdiv_ratio[1]:I mdiv_ratio[0]:I reset_sync__bypassxxnnnl:I ssc__fractionmxh[23]:I ssc__fractionmxh[22]:I
* .PININFO ssc__fractionmxh[21]:I ssc__fractionmxh[20]:I ssc__fractionmxh[19]:I ssc__fractionmxh[18]:I ssc__fractionmxh[17]:I ssc__fractionmxh[16]:I
* .PININFO ssc__fractionmxh[15]:I ssc__fractionmxh[14]:I ssc__fractionmxh[13]:I ssc__fractionmxh[12]:I ssc__fractionmxh[11]:I ssc__fractionmxh[10]:I
* .PININFO ssc__fractionmxh[9]:I ssc__fractionmxh[8]:I ssc__fractionmxh[7]:I ssc__fractionmxh[6]:I ssc__fractionmxh[5]:I ssc__fractionmxh[4]:I
* .PININFO ssc__fractionmxh[3]:I ssc__fractionmxh[2]:I ssc__fractionmxh[1]:I ssc__fractionmxh[0]:I ssc__ratiomxh[9]:I ssc__ratiomxh[8]:I
* .PININFO ssc__ratiomxh[7]:I ssc__ratiomxh[6]:I ssc__ratiomxh[5]:I ssc__ratiomxh[4]:I ssc__ratiomxh[3]:I ssc__ratiomxh[2]:I ssc__ratiomxh[1]:I
* .PININFO ssc__ratiomxh[0]:I vdd:I vssx:I ratio_async_mux__fractionmxh[23]:O ratio_async_mux__fractionmxh[22]:O ratio_async_mux__fractionmxh[21]:O
* .PININFO ratio_async_mux__fractionmxh[20]:O ratio_async_mux__fractionmxh[19]:O ratio_async_mux__fractionmxh[18]:O ratio_async_mux__fractionmxh[17]:O
* .PININFO ratio_async_mux__fractionmxh[16]:O ratio_async_mux__fractionmxh[15]:O ratio_async_mux__fractionmxh[14]:O ratio_async_mux__fractionmxh[13]:O
* .PININFO ratio_async_mux__fractionmxh[12]:O ratio_async_mux__fractionmxh[11]:O ratio_async_mux__fractionmxh[10]:O ratio_async_mux__fractionmxh[9]:O
* .PININFO ratio_async_mux__fractionmxh[8]:O ratio_async_mux__fractionmxh[7]:O ratio_async_mux__fractionmxh[6]:O ratio_async_mux__fractionmxh[5]:O
* .PININFO ratio_async_mux__fractionmxh[4]:O ratio_async_mux__fractionmxh[3]:O ratio_async_mux__fractionmxh[2]:O ratio_async_mux__fractionmxh[1]:O
* .PININFO ratio_async_mux__fractionmxh[0]:O ratio_async_mux__ratiomxh[9]:O ratio_async_mux__ratiomxh[8]:O ratio_async_mux__ratiomxh[7]:O
* .PININFO ratio_async_mux__ratiomxh[6]:O ratio_async_mux__ratiomxh[5]:O ratio_async_mux__ratiomxh[4]:O ratio_async_mux__ratiomxh[3]:O
* .PININFO ratio_async_mux__ratiomxh[2]:O ratio_async_mux__ratiomxh[1]:O ratio_async_mux__ratiomxh[0]:O
Xu15 buft_net_150 ssc__ratiomxh[8] dfx__ratio[8] n4 ratio_async_mux__ratiomxh[8] vdd vssx ringpll__b15ao0022al1n03x3 m=1
Xu22 buft_net_149 ssc__fractionmxh[5] dfx__fraction[5] n4 ratio_async_mux__fractionmxh[5] vdd vssx ringpll__b15ao0022al1n03x3 m=1
Xu21 buft_net_149 ssc__fractionmxh[4] dfx__fraction[4] n4 ratio_async_mux__fractionmxh[4] vdd vssx ringpll__b15ao0022al1n03x3 m=1
Xu20 buft_net_149 ssc__fractionmxh[3] dfx__fraction[3] n4 ratio_async_mux__fractionmxh[3] vdd vssx ringpll__b15ao0022al1n03x3 m=1
Xu14 buft_net_150 ssc__ratiomxh[7] dfx__ratio[7] n4 ratio_async_mux__ratiomxh[7] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu13 buft_net_150 ssc__ratiomxh[6] dfx__ratio[6] n4 ratio_async_mux__ratiomxh[6] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu12 buft_net_150 ssc__ratiomxh[5] dfx__ratio[5] n4 ratio_async_mux__ratiomxh[5] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu11 buft_net_150 ssc__ratiomxh[4] dfx__ratio[4] n4 ratio_async_mux__ratiomxh[4] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu10 buft_net_150 ssc__ratiomxh[3] dfx__ratio[3] n4 ratio_async_mux__ratiomxh[3] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu9 buft_net_150 ssc__ratiomxh[2] dfx__ratio[2] n4 ratio_async_mux__ratiomxh[2] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu8 buft_net_150 ssc__ratiomxh[1] dfx__ratio[1] n4 ratio_async_mux__ratiomxh[1] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu7 buft_net_150 ssc__ratiomxh[0] dfx__ratio[0] n4 ratio_async_mux__ratiomxh[0] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu41 buft_net_149 ssc__fractionmxh[22] dfx__fraction[22] n4 ratio_async_mux__fractionmxh[22] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu31 buft_net_149 ssc__fractionmxh[12] dfx__fraction[12] n4 ratio_async_mux__fractionmxh[12] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu18 buft_net_149 ssc__fractionmxh[1] dfx__fraction[1] n4 ratio_async_mux__fractionmxh[1] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu19 buft_net_149 ssc__fractionmxh[2] dfx__fraction[2] n4 ratio_async_mux__fractionmxh[2] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu6 buft_net_150 ssc__fractionmxh[23] dfx__fraction[23] n4 ratio_async_mux__fractionmxh[23] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu40 buft_net_149 ssc__fractionmxh[21] dfx__fraction[21] n4 ratio_async_mux__fractionmxh[21] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu39 buft_net_149 ssc__fractionmxh[20] dfx__fraction[20] n4 ratio_async_mux__fractionmxh[20] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu38 buft_net_149 ssc__fractionmxh[19] dfx__fraction[19] n4 ratio_async_mux__fractionmxh[19] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu37 buft_net_150 ssc__fractionmxh[18] dfx__fraction[18] n4 ratio_async_mux__fractionmxh[18] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu36 buft_net_150 ssc__fractionmxh[17] dfx__fraction[17] n4 ratio_async_mux__fractionmxh[17] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu35 buft_net_149 ssc__fractionmxh[16] dfx__fraction[16] n4 ratio_async_mux__fractionmxh[16] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu34 buft_net_149 ssc__fractionmxh[15] dfx__fraction[15] n4 ratio_async_mux__fractionmxh[15] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu33 buft_net_149 ssc__fractionmxh[14] dfx__fraction[14] n4 ratio_async_mux__fractionmxh[14] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu32 buft_net_149 ssc__fractionmxh[13] dfx__fraction[13] n4 ratio_async_mux__fractionmxh[13] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu30 buft_net_149 ssc__fractionmxh[11] dfx__fraction[11] n4 ratio_async_mux__fractionmxh[11] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu29 buft_net_149 ssc__fractionmxh[10] dfx__fraction[10] n4 ratio_async_mux__fractionmxh[10] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu27 buft_net_149 ssc__fractionmxh[9] dfx__fraction[9] n4 ratio_async_mux__fractionmxh[9] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu26 buft_net_149 ssc__fractionmxh[8] dfx__fraction[8] n4 ratio_async_mux__fractionmxh[8] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu24 buft_net_149 ssc__fractionmxh[7] dfx__fraction[7] n4 ratio_async_mux__fractionmxh[7] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu23 buft_net_149 ssc__fractionmxh[6] dfx__fraction[6] n4 ratio_async_mux__fractionmxh[6] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu17 buft_net_149 ssc__fractionmxh[0] dfx__fraction[0] n4 ratio_async_mux__fractionmxh[0] vdd vssx ringpll__b15ao0022al1n04x5 m=1
Xu42 buft_net_150 ssc__ratiomxh[9] dfx__ratio[9] n4 ratio_async_mux__ratiomxh[9] vdd vssx ringpll__b15ao0022al1n04x5 m=1
Xplace_binv_r_150 n4 buft_net_150 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_149 n4 buft_net_149 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xu1 mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] n1 vdd vssx ringpll__b15nor004an1n02x7 m=1
Xu2 reset_sync__bypassxxnnnl mdiv_ratio[5] lockxxnnnl n1 n4 vdd vssx ringpll__b15nona23ah1n16x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    mash_carry_3_1
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mash_carry_3_1 clkmodmxh lockxxnnnl reg_req_ack__mashstateresetmxh carryinmxh[2] carryinmxh[1] carryinmxh[0] carryindelaymxh[2] carryindelaymxh[1] carryindelaymxh[0] sdstagecarrymxh carryoutmxh[3] carryoutmxh[2] carryoutmxh[1] carryoutmxh[0] carryoutdelaymxh[3] carryoutdelaymxh[2] carryoutdelaymxh[1] carryoutdelaymxh[0] vdd vssx
* .PININFO carryindelaymxh[2]:I carryindelaymxh[1]:I carryindelaymxh[0]:I carryinmxh[2]:I carryinmxh[1]:I carryinmxh[0]:I clkmodmxh:I lockxxnnnl:I
* .PININFO reg_req_ack__mashstateresetmxh:I sdstagecarrymxh:I vdd:I vssx:I carryoutdelaymxh[3]:O carryoutdelaymxh[2]:O carryoutdelaymxh[1]:O
* .PININFO carryoutdelaymxh[0]:O carryoutmxh[3]:O carryoutmxh[2]:O carryoutmxh[1]:O carryoutmxh[0]:O
Xu7 carryinmxh[2] n2 n10 vdd vssx ringpll__b15nor002an1n03x5 m=1
Xu3 carryinmxh[1] carryindelaymxh[1] n8 vdd vssx ringpll__b15nor002an1n03x5 m=1
Xu6 carryindelaymxh[2] n2 vdd vssx ringpll__b15inv040al1n03x5 m=1
Xu5 sdstagecarrymxh carryinmxh[0] carryindelaymxh[0] n3 carryoutmxh[0] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu9 n5 n4 n3 n6 carryoutmxh[1] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu10 n6 n7 n8 n9 carryoutmxh[2] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu8 n10 carryinmxh[2] n2 n7 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu12 n9 n10 carryoutmxh[3] vdd vssx ringpll__b15xnr002al1n03x5 m=1
Xu1 carryindelaymxh[0] n5 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu4 n8 carryindelaymxh[1] carryinmxh[1] n4 vdd vssx ringpll__b15aoi012an1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    mash_carry_2_0
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mash_carry_2_0 clkmodmxh lockxxnnnl reg_req_ack__mashstateresetmxh carryinmxh[1] carryinmxh[0] carryindelaymxh[1] carryindelaymxh[0] sdstagecarrymxh carryoutmxh[2] carryoutmxh[1] carryoutmxh[0] carryoutdelaymxh[2] carryoutdelaymxh[1] carryoutdelaymxh[0] vdd vssx p_abuf0 p61
* .PININFO carryindelaymxh[1]:I carryindelaymxh[0]:I carryinmxh[1]:I carryinmxh[0]:I clkmodmxh:I lockxxnnnl:I p61:I p_abuf0:I
* .PININFO reg_req_ack__mashstateresetmxh:I sdstagecarrymxh:I vdd:I vssx:I carryoutdelaymxh[2]:O carryoutdelaymxh[1]:O carryoutdelaymxh[0]:O
* .PININFO carryoutmxh[2]:O carryoutmxh[1]:O carryoutmxh[0]:O
Xu14 n10 carryoutmxh[0] vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu4 sdstagecarrymxh n2 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu13 n7 carryinmxh[0] n6 n10 vdd vssx ringpll__b15oai012al1n03x5 m=1
Xu9 carryinmxh[0] n6 n7 vdd vssx ringpll__b15nand02ah1n06x5 m=1
Xu8 n8 carryindelaymxh[0] n2 n6 vdd vssx ringpll__b15oai012an1n03x5 m=1
Xu5 n2 carryindelaymxh[0] n8 vdd vssx ringpll__b15nandp2an1n04x5 m=1
Xu15 p61 n8 n7 n50 carryoutmxh[1] vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu11 n50 n8 carryoutmxh[2] vdd vssx ringpll__b15xor002an1n02x5 m=1
Xcarryoutdelaymxh_reg[1] clkmodmxh n4 carryoutdelaymxh[1] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryoutdelaymxh_reg[0] clkmodmxh n3 carryoutdelaymxh[0] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryoutdelaymxh_reg[2] p_abuf0 net114 carryoutdelaymxh[2] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xu526 n5 net114 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu12 carryoutmxh[2] reg_req_ack__mashstateresetmxh n5 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu18 reg_req_ack__mashstateresetmxh carryoutmxh[1] n4 vdd vssx ringpll__b15norp02al1n02x5 m=1
Xu17 n10 reg_req_ack__mashstateresetmxh n3 vdd vssx ringpll__b15norp02al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    sigma_delta_23_0
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__sigma_delta_23_0 clkmodmxh lockxxnnnl reg_req_ack__mashstateresetmxh fractionmxh[22] fractionmxh[21] fractionmxh[20] fractionmxh[19] fractionmxh[18] fractionmxh[17] fractionmxh[16] fractionmxh[15] fractionmxh[14] fractionmxh[13] fractionmxh[12] fractionmxh[11] fractionmxh[10] fractionmxh[9] fractionmxh[8] fractionmxh[7] fractionmxh[6] fractionmxh[5] fractionmxh[4] fractionmxh[3] fractionmxh[2] fractionmxh[1] fractionmxh[0] errvalmxh[22] errvalmxh[21] errvalmxh[20] errvalmxh[19] errvalmxh[18] errvalmxh[17] errvalmxh[16] errvalmxh[15] errvalmxh[14] errvalmxh[13] errvalmxh[12] errvalmxh[11] errvalmxh[10] errvalmxh[9] errvalmxh[8] errvalmxh[7] errvalmxh[6] errvalmxh[5] errvalmxh[4] errvalmxh[3] errvalmxh[2] errvalmxh[1] errvalmxh[0] carrymxh vdd vssx p_abuf0 p_abuf1 p_abuf2 p_abuf3 p_abuf4 p_abuf5 p_abuf6
* .PININFO clkmodmxh:I fractionmxh[22]:I fractionmxh[21]:I fractionmxh[20]:I fractionmxh[19]:I fractionmxh[18]:I fractionmxh[17]:I fractionmxh[16]:I
* .PININFO fractionmxh[15]:I fractionmxh[14]:I fractionmxh[13]:I fractionmxh[12]:I fractionmxh[11]:I fractionmxh[10]:I fractionmxh[9]:I
* .PININFO fractionmxh[8]:I fractionmxh[7]:I fractionmxh[6]:I fractionmxh[5]:I fractionmxh[4]:I fractionmxh[3]:I fractionmxh[2]:I fractionmxh[1]:I
* .PININFO fractionmxh[0]:I lockxxnnnl:I p_abuf0:I p_abuf1:I p_abuf2:I p_abuf3:I p_abuf4:I p_abuf5:I p_abuf6:I reg_req_ack__mashstateresetmxh:I vdd:I
* .PININFO vssx:I carrymxh:O errvalmxh[22]:O errvalmxh[21]:O errvalmxh[20]:O errvalmxh[19]:O errvalmxh[18]:O errvalmxh[17]:O errvalmxh[16]:O
* .PININFO errvalmxh[15]:O errvalmxh[14]:O errvalmxh[13]:O errvalmxh[12]:O errvalmxh[11]:O errvalmxh[10]:O errvalmxh[9]:O errvalmxh[8]:O
* .PININFO errvalmxh[7]:O errvalmxh[6]:O errvalmxh[5]:O errvalmxh[4]:O errvalmxh[3]:O errvalmxh[2]:O errvalmxh[1]:O errvalmxh[0]:O
Xu53 fractionmxh[22] carryerrvalmxh[22] n54 vdd vssx ringpll__b15norp02ah1n03x5 m=1
Xu56 n47 n52 n49 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu7 fractionmxh[0] carryerrvalmxh[0] n5 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu55 fractionmxh[22] carryerrvalmxh[22] n52 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu62 n55 p_abuf5 carrymxh vdd vssx ringpll__b15nonb02ah1n02x3 m=1
Xu61 n52 n54 n53 n55 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu60 n51 n53 vdd vssx ringpll__b15inv020ah1n03x5 m=1
Xu28 n22 reg_req_ack__mashstateresetmxh n_68 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu26 n20 reg_req_ack__mashstateresetmxh n_69 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu24 n18 reg_req_ack__mashstateresetmxh n_70 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu22 n16 reg_req_ack__mashstateresetmxh n_71 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu20 n14 reg_req_ack__mashstateresetmxh n_72 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu18 n12 reg_req_ack__mashstateresetmxh n_73 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu16 n10 reg_req_ack__mashstateresetmxh n_74 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu14 n8 reg_req_ack__mashstateresetmxh n_75 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu12 n6 reg_req_ack__mashstateresetmxh n_76 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu30 n24 reg_req_ack__mashstateresetmxh n_67 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu32 n26 reg_req_ack__mashstateresetmxh n_66 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu34 n28 reg_req_ack__mashstateresetmxh n_65 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu36 n30 reg_req_ack__mashstateresetmxh n_64 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu38 n32 reg_req_ack__mashstateresetmxh n_63 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu40 n34 reg_req_ack__mashstateresetmxh n_62 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu42 n36 reg_req_ack__mashstateresetmxh n_61 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu44 n38 p_abuf5 n_60 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu46 n40 p_abuf5 n_59 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu48 n42 p_abuf5 n_57 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu50 n44 p_abuf5 n_56 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu52 n46 p_abuf5 n_4 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu10 n58 p_abuf5 n_77 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu59 n50 p_abuf5 n_3 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu11 n5 n7 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu6 n1 n2 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu54 n54 n47 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu58 n49 n51 n50 vdd vssx ringpll__b15xnr002al1n02x5 m=1
Xu527 n_68 net115 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu514 n_69 net102 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu515 n_70 net103 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu516 n_71 net104 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu517 n_72 net105 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu518 n_73 net106 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu513 n_74 net101 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu494 n_75 net82 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu488 n_76 net76 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu543 n_67 net131 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu545 n_66 net133 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu540 n_65 net128 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu541 n_64 net129 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu544 n_63 net132 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu538 n_62 net126 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu535 n_61 net123 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu485 n_60 net73 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu487 n_59 net75 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu476 n_57 net64 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu484 n_56 net72 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu481 n_4 net69 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu490 n_77 net78 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu483 n_3 net71 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xcarryerrvalmxh_reg[10] clkmodmxh net131 carryerrvalmxh[10] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[19] clkmodmxh net64 carryerrvalmxh[19] p_abuf4 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[12] clkmodmxh net128 carryerrvalmxh[12] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[20] clkmodmxh net72 carryerrvalmxh[20] p_abuf4 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[13] clkmodmxh net129 carryerrvalmxh[13] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[18] clkmodmxh net75 carryerrvalmxh[18] p_abuf1 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[14] clkmodmxh net132 carryerrvalmxh[14] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[17] clkmodmxh net73 carryerrvalmxh[17] p_abuf6 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[15] clkmodmxh net126 carryerrvalmxh[15] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[16] clkmodmxh net123 carryerrvalmxh[16] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[11] clkmodmxh net133 carryerrvalmxh[11] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[8] clkmodmxh net102 carryerrvalmxh[8] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[6] clkmodmxh net104 carryerrvalmxh[6] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[4] clkmodmxh net106 carryerrvalmxh[4] p_abuf1 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[2] clkmodmxh net82 carryerrvalmxh[2] p_abuf1 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[1] clkmodmxh net76 carryerrvalmxh[1] p_abuf1 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[3] clkmodmxh net101 carryerrvalmxh[3] p_abuf1 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[5] clkmodmxh net105 carryerrvalmxh[5] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[7] clkmodmxh net103 carryerrvalmxh[7] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[9] clkmodmxh net115 carryerrvalmxh[9] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[21] clkmodmxh net69 carryerrvalmxh[21] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[0] clkmodmxh net78 carryerrvalmxh[0] p_abuf1 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[22] clkmodmxh net71 carryerrvalmxh[22] p_abuf3 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xu5 fractionmxh[0] carryerrvalmxh[0] n1 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu3 n5 n2 n58 vdd vssx ringpll__b15and002al1n03x5 m=1
Xu15 n9 carryerrvalmxh[2] fractionmxh[2] n11 n8 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu39 n33 carryerrvalmxh[14] fractionmxh[14] n35 n32 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu51 n45 carryerrvalmxh[20] fractionmxh[20] n48 n44 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu57 n48 carryerrvalmxh[21] fractionmxh[21] n51 n46 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu31 n25 carryerrvalmxh[10] fractionmxh[10] n27 n24 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu29 n23 carryerrvalmxh[9] fractionmxh[9] n25 n22 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu27 carryerrvalmxh[8] n21 fractionmxh[8] n23 n20 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu25 n19 carryerrvalmxh[7] fractionmxh[7] n21 n18 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu21 n15 carryerrvalmxh[5] fractionmxh[5] n17 n14 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu23 carryerrvalmxh[6] n17 fractionmxh[6] n19 n16 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu19 n13 carryerrvalmxh[4] fractionmxh[4] n15 n12 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu17 n11 carryerrvalmxh[3] fractionmxh[3] n13 n10 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu33 carryerrvalmxh[11] n27 fractionmxh[11] n29 n26 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu35 n29 carryerrvalmxh[12] fractionmxh[12] n31 n28 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu37 n31 carryerrvalmxh[13] fractionmxh[13] n33 n30 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu41 carryerrvalmxh[15] n35 fractionmxh[15] n37 n34 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu43 n37 carryerrvalmxh[16] fractionmxh[16] n39 n36 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu47 n41 carryerrvalmxh[18] fractionmxh[18] n43 n40 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu49 n43 carryerrvalmxh[19] fractionmxh[19] n45 n42 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu45 n39 carryerrvalmxh[17] fractionmxh[17] n41 n38 vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu13 fractionmxh[1] carryerrvalmxh[1] n7 n9 n6 vdd vssx ringpll__b15rm0023al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ssc_mod
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ssc_mod ssc_mod_dfx__clkmodmxh lockxxnnnl dfx__ratiostepnh[9] dfx__ratiostepnh[8] dfx__ratiostepnh[7] dfx__ratiostepnh[6] dfx__ratiostepnh[5] dfx__ratiostepnh[4] dfx__ratiostepnh[3] dfx__ratiostepnh[2] dfx__ratiostepnh[1] dfx__ratiostepnh[0] dfx__fracstepnh[23] dfx__fracstepnh[22] dfx__fracstepnh[21] dfx__fracstepnh[20] dfx__fracstepnh[19] dfx__fracstepnh[18] dfx__fracstepnh[17] dfx__fracstepnh[16] dfx__fracstepnh[15] dfx__fracstepnh[14] dfx__fracstepnh[13] dfx__fracstepnh[12] dfx__fracstepnh[11] dfx__fracstepnh[10] dfx__fracstepnh[9] dfx__fracstepnh[8] dfx__fracstepnh[7] dfx__fracstepnh[6] dfx__fracstepnh[5] dfx__fracstepnh[4] dfx__fracstepnh[3] dfx__fracstepnh[2] dfx__fracstepnh[1] dfx__fracstepnh[0] dfx__ssc_en dfx__ssc_mode[1] dfx__ssc_mode[0] dfx__ssc_cyc_to_peak_m1[8] dfx__ssc_cyc_to_peak_m1[7] dfx__ssc_cyc_to_peak_m1[6] dfx__ssc_cyc_to_peak_m1[5] dfx__ssc_cyc_to_peak_m1[4] dfx__ssc_cyc_to_peak_m1[3] dfx__ssc_cyc_to_peak_m1[2] dfx__ssc_cyc_to_peak_m1[1] dfx__ssc_cyc_to_peak_m1[0] reg_req_ack__sscprofupdreqmxh reg_req_ack__sscprofupdackmxh reg_req_ack__ratioupdreqmxh reg_req_ack__ratioupdackmxh dfx__ratio[9] dfx__ratio[8] dfx__ratio[7] dfx__ratio[6] dfx__ratio[5] dfx__ratio[4] dfx__ratio[3] dfx__ratio[2] dfx__ratio[1] dfx__ratio[0] dfx__fraction[23] dfx__fraction[22] dfx__fraction[21] dfx__fraction[20] dfx__fraction[19] dfx__fraction[18] dfx__fraction[17] dfx__fraction[16] dfx__fraction[15] dfx__fraction[14] dfx__fraction[13] dfx__fraction[12] dfx__fraction[11] dfx__fraction[10] dfx__fraction[9] dfx__fraction[8] dfx__fraction[7] dfx__fraction[6] dfx__fraction[5] dfx__fraction[4] dfx__fraction[3] dfx__fraction[2] dfx__fraction[1] dfx__fraction[0] ssc__ratiomxh[9] ssc__ratiomxh[8] ssc__ratiomxh[7] ssc__ratiomxh[6] ssc__ratiomxh[5] ssc__ratiomxh[4] ssc__ratiomxh[3] ssc__ratiomxh[2] ssc__ratiomxh[1] ssc__ratiomxh[0] ssc__fractionmxh[23] ssc__fractionmxh[22] ssc__fractionmxh[21] ssc__fractionmxh[20] ssc__fractionmxh[19] ssc__fractionmxh[18] ssc__fractionmxh[17] ssc__fractionmxh[16] ssc__fractionmxh[15] ssc__fractionmxh[14] ssc__fractionmxh[13] ssc__fractionmxh[12] ssc__fractionmxh[11] ssc__fractionmxh[10] ssc__fractionmxh[9] ssc__fractionmxh[8] ssc__fractionmxh[7] ssc__fractionmxh[6] ssc__fractionmxh[5] ssc__fractionmxh[4] ssc__fractionmxh[3] ssc__fractionmxh[2] ssc__fractionmxh[1] ssc__fractionmxh[0] ssc__directionmxh ssc__profupdatemxh ssc__ratioupdatemxh vdd vssx p_abuf0 p0 p_abuf1
* .PININFO dfx__fracstepnh[23]:I dfx__fracstepnh[22]:I dfx__fracstepnh[21]:I dfx__fracstepnh[20]:I dfx__fracstepnh[19]:I dfx__fracstepnh[18]:I
* .PININFO dfx__fracstepnh[17]:I dfx__fracstepnh[16]:I dfx__fracstepnh[15]:I dfx__fracstepnh[14]:I dfx__fracstepnh[13]:I dfx__fracstepnh[12]:I
* .PININFO dfx__fracstepnh[11]:I dfx__fracstepnh[10]:I dfx__fracstepnh[9]:I dfx__fracstepnh[8]:I dfx__fracstepnh[7]:I dfx__fracstepnh[6]:I
* .PININFO dfx__fracstepnh[5]:I dfx__fracstepnh[4]:I dfx__fracstepnh[3]:I dfx__fracstepnh[2]:I dfx__fracstepnh[1]:I dfx__fracstepnh[0]:I
* .PININFO dfx__fraction[23]:I dfx__fraction[22]:I dfx__fraction[21]:I dfx__fraction[20]:I dfx__fraction[19]:I dfx__fraction[18]:I dfx__fraction[17]:I
* .PININFO dfx__fraction[16]:I dfx__fraction[15]:I dfx__fraction[14]:I dfx__fraction[13]:I dfx__fraction[12]:I dfx__fraction[11]:I dfx__fraction[10]:I
* .PININFO dfx__fraction[9]:I dfx__fraction[8]:I dfx__fraction[7]:I dfx__fraction[6]:I dfx__fraction[5]:I dfx__fraction[4]:I dfx__fraction[3]:I
* .PININFO dfx__fraction[2]:I dfx__fraction[1]:I dfx__fraction[0]:I dfx__ratio[9]:I dfx__ratio[8]:I dfx__ratio[7]:I dfx__ratio[6]:I dfx__ratio[5]:I
* .PININFO dfx__ratio[4]:I dfx__ratio[3]:I dfx__ratio[2]:I dfx__ratio[1]:I dfx__ratio[0]:I dfx__ratiostepnh[9]:I dfx__ratiostepnh[8]:I
* .PININFO dfx__ratiostepnh[7]:I dfx__ratiostepnh[6]:I dfx__ratiostepnh[5]:I dfx__ratiostepnh[4]:I dfx__ratiostepnh[3]:I dfx__ratiostepnh[2]:I
* .PININFO dfx__ratiostepnh[1]:I dfx__ratiostepnh[0]:I dfx__ssc_cyc_to_peak_m1[8]:I dfx__ssc_cyc_to_peak_m1[7]:I dfx__ssc_cyc_to_peak_m1[6]:I
* .PININFO dfx__ssc_cyc_to_peak_m1[5]:I dfx__ssc_cyc_to_peak_m1[4]:I dfx__ssc_cyc_to_peak_m1[3]:I dfx__ssc_cyc_to_peak_m1[2]:I
* .PININFO dfx__ssc_cyc_to_peak_m1[1]:I dfx__ssc_cyc_to_peak_m1[0]:I dfx__ssc_en:I dfx__ssc_mode[1]:I dfx__ssc_mode[0]:I lockxxnnnl:I p0:I p_abuf0:I
* .PININFO p_abuf1:I reg_req_ack__ratioupdackmxh:I reg_req_ack__ratioupdreqmxh:I reg_req_ack__sscprofupdackmxh:I reg_req_ack__sscprofupdreqmxh:I
* .PININFO ssc_mod_dfx__clkmodmxh:I vdd:I vssx:I ssc__directionmxh:O ssc__fractionmxh[23]:O ssc__fractionmxh[22]:O ssc__fractionmxh[21]:O
* .PININFO ssc__fractionmxh[20]:O ssc__fractionmxh[19]:O ssc__fractionmxh[18]:O ssc__fractionmxh[17]:O ssc__fractionmxh[16]:O ssc__fractionmxh[15]:O
* .PININFO ssc__fractionmxh[14]:O ssc__fractionmxh[13]:O ssc__fractionmxh[12]:O ssc__fractionmxh[11]:O ssc__fractionmxh[10]:O ssc__fractionmxh[9]:O
* .PININFO ssc__fractionmxh[8]:O ssc__fractionmxh[7]:O ssc__fractionmxh[6]:O ssc__fractionmxh[5]:O ssc__fractionmxh[4]:O ssc__fractionmxh[3]:O
* .PININFO ssc__fractionmxh[2]:O ssc__fractionmxh[1]:O ssc__fractionmxh[0]:O ssc__profupdatemxh:O ssc__ratiomxh[9]:O ssc__ratiomxh[8]:O
* .PININFO ssc__ratiomxh[7]:O ssc__ratiomxh[6]:O ssc__ratiomxh[5]:O ssc__ratiomxh[4]:O ssc__ratiomxh[3]:O ssc__ratiomxh[2]:O ssc__ratiomxh[1]:O
* .PININFO ssc__ratiomxh[0]:O ssc__ratioupdatemxh:O
Xu47 ssc__directionmxh n44 cyctopeakm1mxh[8] n98 n23 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu224 n77 n257 buft_net_146 n76 n81 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu235 counttopeakmxh[1] n103 dfx__ssc_cyc_to_peak_m1[1] n56 n88 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu56 n32 cyctopeakm1mxh[5] n470 n31 n35 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu49 cyctopeakm1mxh[2] n26 cyctopeakm1mxh[1] n25 n36 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu241 counttopeakmxh[0] n103 n56 dfx__ssc_cyc_to_peak_m1[0] n95 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu238 counttopeakmxh[4] n103 n56 dfx__ssc_cyc_to_peak_m1[4] n91 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu95 counttopeakmxh[8] n103 n56 dfx__ssc_cyc_to_peak_m1[8] n66 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu97 counttopeakmxh[2] n103 n56 dfx__ssc_cyc_to_peak_m1[2] n69 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu250 counttopeakmxh[3] n103 n56 dfx__ssc_cyc_to_peak_m1[3] n106 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu247 counttopeakmxh[5] n103 n56 dfx__ssc_cyc_to_peak_m1[5] n100 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu80 counttopeakmxh[6] n103 n56 dfx__ssc_cyc_to_peak_m1[6] n58 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu244 counttopeakmxh[7] n103 n56 dfx__ssc_cyc_to_peak_m1[7] n97 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu316 ratiostepmxh_0 n230 n231 buft_net_151 n237 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu309 ratiostepmxh_0 n221 n222 buft_net_151 n227 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu302 ratiostepmxh_0 n210 n211 buft_net_151 n217 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu322 fracstepmxh[23] n241 n242 n243 n247 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu296 ratiostepmxh_0 n201 n202 buft_net_151 n207 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu289 ratiostepmxh_0 n192 n193 buft_net_152 n198 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu276 ratiostepmxh_0 n174 n175 buft_net_152 n180 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu260 ratiostepmxh_0 n157 n156 buft_net_151 n158 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu283 ratiostepmxh_0 n183 n184 buft_net_152 n189 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu255 n109 buft_net_146 n257 n110 n156 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu363 fracstepmxh[17] n297 n298 n299 n303 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu337 fracstepmxh[21] n260 n261 n262 n266 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu376 fracstepmxh[15] n315 n316 n317 n321 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu389 fracstepmxh[13] n333 n334 n335 n339 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu402 fracstepmxh[11] n351 n352 n353 n357 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu350 fracstepmxh[19] n279 n280 n281 n285 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu454 fracstepmxh[3] n428 n429 n430 n434 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu441 fracstepmxh[5] n407 n408 n409 n413 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu428 fracstepmxh[7] n389 n390 n391 n395 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu435 fracstepmxh[6] n398 n399 n400 n404 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu422 fracstepmxh[8] n380 n381 n382 n386 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu415 fracstepmxh[9] n370 n371 n372 n376 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu467 fracstepmxh[1] n454 n455 n456 n462 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu461 fracstepmxh[2] n439 n440 n469 n447 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu448 fracstepmxh[4] n416 n417 n468 n422 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu396 fracstepmxh[12] n342 n343 n344 n348 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu370 fracstepmxh[16] n306 n307 n308 n312 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu344 fracstepmxh[20] n269 n270 n271 n275 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu383 fracstepmxh[14] n324 n325 n326 n330 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu330 fracstepmxh[22] n250 n251 n252 n256 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu357 fracstepmxh[18] n288 n289 n290 n294 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu267 ratiostepmxh_0 n164 n165 buft_net_152 n170 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu409 fracstepmxh[10] n361 n362 n363 n367 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu226 n482 ratiostepmxh_0 n81 buft_net_151 n84 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu221 n76 n72 buft_net_148 n77 n482 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu258 buft_net_151 n156 n157 ratiostepmxh_0 n161 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu317 buft_net_151 n231 n230 ratiostepmxh_0 n233 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu311 buft_net_151 n222 n221 ratiostepmxh_0 n224 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu303 buft_net_151 n211 n210 ratiostepmxh_0 n213 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu324 n243 n242 n241 fracstepmxh[23] n244 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu297 buft_net_151 n202 n201 ratiostepmxh_0 n204 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu290 buft_net_152 n193 n192 ratiostepmxh_0 n195 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu284 buft_net_152 n184 n183 ratiostepmxh_0 n186 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu277 buft_net_152 n175 n174 ratiostepmxh_0 n177 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu257 n110 buft_net_148 n72 n109 n157 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu351 n281 n280 n279 fracstepmxh[19] n282 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu364 n299 n298 n297 fracstepmxh[17] n300 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu338 n262 n261 n260 fracstepmxh[21] n263 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu377 n317 n316 n315 fracstepmxh[15] n318 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu390 n335 n334 n333 fracstepmxh[13] n336 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu403 n353 n352 n351 fracstepmxh[11] n354 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu436 n400 n399 n398 fracstepmxh[6] n401 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu423 n382 n381 n380 fracstepmxh[8] n383 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu416 n372 n371 n370 fracstepmxh[9] n373 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu468 n456 n455 n454 fracstepmxh[1] n457 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu455 n430 n429 n428 fracstepmxh[3] n431 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu442 n409 n408 n407 fracstepmxh[5] n410 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu429 n391 n390 n389 fracstepmxh[7] n392 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu462 n469 n440 n439 fracstepmxh[2] n442 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu449 n468 n417 n416 fracstepmxh[4] n419 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu397 n344 n343 n342 fracstepmxh[12] n345 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu371 n308 n307 n306 fracstepmxh[16] n309 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu345 n271 n270 n269 fracstepmxh[20] n272 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu384 n326 n325 n324 fracstepmxh[14] n327 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu331 n252 n251 n250 fracstepmxh[22] n253 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu358 n290 n289 n288 fracstepmxh[18] n291 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu268 buft_net_152 n165 n164 ratiostepmxh_0 n167 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu410 n363 n362 n361 fracstepmxh[10] n364 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu230 ssc__ratiomxh[9] n82 dfx__ratio[9] n220 n83 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu93 ssc__fractionmxh[0] n64 dfx__fraction[0] n220 n65 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu318 dfx__ratio[1] n220 n235 n233 n234 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu312 dfx__ratio[2] n220 n226 n224 n225 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu304 dfx__ratio[3] n220 n216 n213 n215 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu325 dfx__fraction[23] n220 n246 n244 n245 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu298 dfx__ratio[4] n220 n206 n204 n205 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu291 dfx__ratio[5] n220 n197 n195 n196 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu285 dfx__ratio[6] n220 n188 net66 n187 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu278 dfx__ratio[7] n220 n179 n177 n178 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu261 dfx__ratio[0] n220 n160 n158 n159 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu365 dfx__fraction[17] n220 n302 n300 n301 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu339 dfx__fraction[21] n220 n265 n263 n264 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu378 dfx__fraction[15] n220 n320 n318 n319 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu391 dfx__fraction[13] n220 n338 n336 n337 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu404 dfx__fraction[11] n220 n356 n354 n355 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu352 dfx__fraction[19] n220 n284 n282 n283 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu456 dfx__fraction[3] n220 n433 n431 n432 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu443 dfx__fraction[5] n220 n412 n410 n411 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu430 dfx__fraction[7] n220 n394 n392 n393 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu437 dfx__fraction[6] n220 n403 n401 n402 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu424 dfx__fraction[8] n220 n385 n383 n384 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu417 dfx__fraction[9] n220 n375 n373 n374 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu469 dfx__fraction[1] n220 n460 n457 n459 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu463 dfx__fraction[2] n220 n445 n442 n444 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu450 dfx__fraction[4] n220 n421 n419 n420 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu411 dfx__fraction[10] n220 n366 n364 n365 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu398 dfx__fraction[12] n220 n347 n345 n346 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu372 dfx__fraction[16] n220 n311 n309 n310 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu346 dfx__fraction[20] n220 n274 n272 n273 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu385 dfx__fraction[14] n220 n329 n327 n328 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu332 dfx__fraction[22] n220 n255 n253 n254 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu359 dfx__fraction[18] n220 n293 n291 n292 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu269 dfx__ratio[8] n220 n169 n167 n168 vdd vssx ringpll__b15aoi022an1n02x3 m=1
Xu68 n49 ratiostepmxh_0 n51 n50 n52 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu319 n234 n235 n237 n240 n136 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu313 n225 n226 n227 n240 n137 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu305 n215 n216 n217 n240 n138 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu326 n245 n246 n247 n240 n134 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu299 n205 n206 n207 n240 n139 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu292 n196 n197 n198 n240 n140 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu286 n187 n188 net486 n240 n141 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu279 n178 n179 n180 n240 n142 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu262 n159 n160 n161 n240 n145 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu366 n301 n302 n303 n240 n128 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu340 n264 n265 n266 n240 n132 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu379 n319 n320 n321 n240 n126 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu392 n337 n338 n339 n240 n124 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu405 n355 n356 n357 n240 n122 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu353 n283 n284 n285 n240 n130 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu457 n432 n433 n434 n240 n114 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu444 n411 n412 n413 n240 n116 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu431 n393 n394 n395 n240 n118 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu438 n402 n403 n404 n240 n117 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu425 n384 n385 n386 n240 n119 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu418 n374 n375 n376 n240 n120 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu470 n459 n460 n462 n240 n112 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu464 n444 n445 n447 n240 n113 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu451 n420 n421 n422 n240 n115 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu412 n365 n366 n367 n240 n121 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu399 n346 n347 n348 n240 n123 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu373 n310 n311 n312 n240 n127 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu347 n273 n274 n275 n240 n131 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu386 n328 n329 n330 n240 n125 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu333 n254 n255 n256 n240 n133 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu360 n292 n293 n294 n240 n129 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu270 n168 n169 n170 n240 n143 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu266 n144 net38 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu548 n135 net136 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu909 net447 ssc__ratioupdatemxh vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1098 net343 net532 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1013 net532 net447 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1011 net340 net445 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu906 net445 net31 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu264 net31 ssc__profupdatemxh vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu169 n111 net12 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu563 n56 net151 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu556 n56 net144 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu532 n56 net120 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu528 n56 net116 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu522 n56 net110 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu521 n56 net109 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu520 n56 net108 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu509 n56 net97 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu506 n56 net94 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu505 n56 net93 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu504 n56 net92 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu503 n56 net91 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu502 n56 net90 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu501 n56 net89 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu500 n56 net88 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu498 n56 net86 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu497 n56 net85 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu495 n56 net83 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu493 n56 net81 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu491 n56 net79 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu489 n56 net77 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu486 n56 net74 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu479 n56 net67 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu474 n56 net62 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu460 n56 net51 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu447 n56 net50 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu335 n56 net49 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu274 n56 net43 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu323 n56 net48 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu310 n56 net47 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu308 n56 net46 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu282 n56 net44 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu271 n56 net40 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu259 n56 net32 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu248 n56 net24 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu228 n146 net18 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu225 n154 net17 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu232 n149 net19 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu295 n153 net45 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu233 n147 net20 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu242 n148 net21 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu245 n150 net22 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu480 n151 net68 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu471 n152 net59 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu256 n136 net30 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu251 n137 net26 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu249 n138 net25 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu539 n134 net127 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu252 n139 net27 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu253 n140 net28 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1052 net379 net486 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1 n141 net1 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu254 n142 net29 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu536 n145 net124 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu945 n189 net379 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu835 n186 net66 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu246 n143 net23 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu79 n128 net3 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu553 n132 net141 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu167 n126 net10 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu223 n124 net16 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu172 n122 net14 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu549 n130 net137 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu87 n114 net4 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu102 n116 net7 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu104 n118 net8 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu100 n117 net6 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu106 n119 net9 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu168 n120 net11 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu482 n113 net70 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu519 n112 net107 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu91 n115 net5 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu171 n121 net13 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu2 n127 net2 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu222 n123 net15 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu554 n131 net142 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu510 n125 net98 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu542 n133 net130 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu546 n129 net134 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xssc__fractionmxh_reg[0] ssc_mod_dfx__clkmodmxh net136 ssc__fractionmxh[0] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[17] p_abuf1 net3 ssc__fractionmxh[17] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[5] p_abuf1 net7 ssc__fractionmxh[5] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[22] ssc_mod_dfx__clkmodmxh net130 ssc__fractionmxh[22] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[20] ssc_mod_dfx__clkmodmxh net142 ssc__fractionmxh[20] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xcounttopeakmxh_reg[0] ssc_mod_dfx__clkmodmxh net17 counttopeakmxh[0] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__ratiomxh_reg[8] ssc_mod_dfx__clkmodmxh net23 ssc__ratiomxh[8] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__ratiomxh_reg[0] ssc_mod_dfx__clkmodmxh net124 ssc__ratiomxh[0] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__ratiomxh_reg[4] ssc_mod_dfx__clkmodmxh net27 ssc__ratiomxh[4] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[18] ssc_mod_dfx__clkmodmxh net134 ssc__fractionmxh[18] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__ratiomxh_reg[2] ssc_mod_dfx__clkmodmxh net26 ssc__ratiomxh[2] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[14] ssc_mod_dfx__clkmodmxh net98 ssc__fractionmxh[14] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[7] p_abuf1 net8 ssc__fractionmxh[7] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__ratiomxh_reg[9] ssc_mod_dfx__clkmodmxh net38 ssc__ratiomxh[9] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[16] p_abuf1 net2 ssc__fractionmxh[16] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[10] p_abuf1 net13 ssc__fractionmxh[10] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[6] p_abuf1 net6 ssc__fractionmxh[6] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[1] ssc_mod_dfx__clkmodmxh net107 ssc__fractionmxh[1] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[8] p_abuf1 net9 ssc__fractionmxh[8] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[2] ssc_mod_dfx__clkmodmxh net70 ssc__fractionmxh[2] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[9] p_abuf1 net11 ssc__fractionmxh[9] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__ratiomxh_reg[5] ssc_mod_dfx__clkmodmxh net28 ssc__ratiomxh[5] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xcounttopeakmxh_reg[1] ssc_mod_dfx__clkmodmxh net18 counttopeakmxh[1] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xcounttopeakmxh_reg[4] ssc_mod_dfx__clkmodmxh net19 counttopeakmxh[4] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[23] ssc_mod_dfx__clkmodmxh net127 ssc__fractionmxh[23] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[15] p_abuf1 net10 ssc__fractionmxh[15] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xcounttopeakmxh_reg[5] ssc_mod_dfx__clkmodmxh net22 counttopeakmxh[5] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[3] p_abuf1 net4 ssc__fractionmxh[3] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xcounttopeakmxh_reg[2] ssc_mod_dfx__clkmodmxh net20 counttopeakmxh[2] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__ratiomxh_reg[6] p_abuf1 net1 ssc__ratiomxh[6] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xcounttopeakmxh_reg[8] ssc_mod_dfx__clkmodmxh net45 counttopeakmxh[8] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__ratiomxh_reg[7] ssc_mod_dfx__clkmodmxh net29 ssc__ratiomxh[7] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[13] p_abuf1 net16 ssc__fractionmxh[13] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xcounttopeakmxh_reg[3] ssc_mod_dfx__clkmodmxh net21 counttopeakmxh[3] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[19] ssc_mod_dfx__clkmodmxh net137 ssc__fractionmxh[19] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xcounttopeakmxh_reg[6] ssc_mod_dfx__clkmodmxh net68 counttopeakmxh[6] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[21] ssc_mod_dfx__clkmodmxh net141 ssc__fractionmxh[21] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[11] p_abuf1 net14 ssc__fractionmxh[11] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xcounttopeakmxh_reg[7] ssc_mod_dfx__clkmodmxh net59 counttopeakmxh[7] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[4] p_abuf1 net5 ssc__fractionmxh[4] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__ratiomxh_reg[3] ssc_mod_dfx__clkmodmxh net25 ssc__ratiomxh[3] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__fractionmxh_reg[12] p_abuf1 net15 ssc__fractionmxh[12] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xssc__ratiomxh_reg[1] ssc_mod_dfx__clkmodmxh net30 ssc__ratiomxh[1] vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xu75 n63 n470 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu173 ssc__ratiomxh[8] n169 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu77 n92 n108 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu70 sscenmxh n78 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu89 n71 n73 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu13 ssc__directionmxh n467 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu62 counttopeakmxh[0] n43 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu35 n9 n11 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu16 cyctopeakm1mxh[5] n4 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu24 cyctopeakm1mxh[1] n14 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu5 counttopeakmxh[3] n1 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu23 cyctopeakm1mxh[2] n12 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu52 n27 n33 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu50 n24 n32 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu38 cyctopeakm1mxh[0] n44 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu4 counttopeakmxh[5] n5 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu3 counttopeakmxh[7] n21 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu130 fracstepmxh[1] n456 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu179 ssc__fractionmxh[20] n274 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu113 ssc__fractionmxh[19] n284 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu110 fracstepmxh[21] n262 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu111 ssc__fractionmxh[21] n265 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu395 fracstepmxh[12] n344 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu434 fracstepmxh[6] n400 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu421 fracstepmxh[8] n382 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu408 fracstepmxh[10] n363 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu188 ssc__fractionmxh[2] n445 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu128 fracstepmxh[3] n430 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu129 ssc__fractionmxh[3] n433 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu186 ssc__fractionmxh[6] n403 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu187 ssc__fractionmxh[4] n421 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu126 fracstepmxh[5] n409 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu127 ssc__fractionmxh[5] n412 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu178 ssc__fractionmxh[22] n255 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu177 ssc__ratiomxh[0] n160 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu108 fracstepmxh[23] n243 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu109 ssc__fractionmxh[23] n246 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu107 ssc__ratiomxh[1] n235 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu176 ssc__ratiomxh[2] n226 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu105 ssc__ratiomxh[3] n216 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu175 ssc__ratiomxh[4] n206 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu103 ssc__ratiomxh[5] n197 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu174 ssc__ratiomxh[6] n188 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu101 ssc__ratiomxh[7] n179 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu123 ssc__fractionmxh[9] n375 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu180 ssc__fractionmxh[18] n293 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu181 ssc__fractionmxh[16] n311 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu182 ssc__fractionmxh[14] n329 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu183 ssc__fractionmxh[12] n347 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu184 ssc__fractionmxh[10] n366 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu112 fracstepmxh[19] n281 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu115 ssc__fractionmxh[17] n302 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu114 fracstepmxh[17] n299 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu117 ssc__fractionmxh[15] n320 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu116 fracstepmxh[15] n317 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu119 ssc__fractionmxh[13] n338 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu118 fracstepmxh[13] n335 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu120 fracstepmxh[11] n353 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu121 ssc__fractionmxh[11] n356 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu122 fracstepmxh[9] n372 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu132 ssc__fractionmxh[1] n460 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu124 fracstepmxh[7] n391 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu185 ssc__fractionmxh[8] n385 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu125 ssc__fractionmxh[7] n394 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu369 fracstepmxh[16] n308 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu356 fracstepmxh[18] n290 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu343 fracstepmxh[20] n271 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu329 fracstepmxh[22] n252 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu382 fracstepmxh[14] n326 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu74 fracstepmxh[2] n469 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu66 fracstepmxh[4] n468 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu220 n169 ratiostepmxh_0 n163 n77 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu164 n162 ratiostepmxh_0 ssc__ratiomxh[8] n76 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu154 n248 fracstepmxh[22] ssc__fractionmxh[22] n238 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu210 n255 fracstepmxh[22] n249 n239 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu212 n160 ratiostepmxh_0 n110 n229 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu211 n243 n239 ssc__fractionmxh[23] n110 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu213 buft_net_151 n229 ssc__ratiomxh[1] n219 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu156 n109 ssc__ratiomxh[0] ratiostepmxh_0 n228 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu155 n243 n246 n238 n109 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu157 buft_net_151 n235 n228 n218 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu158 n218 ratiostepmxh_0 ssc__ratiomxh[2] n208 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu214 n226 ratiostepmxh_0 n219 n209 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu215 buft_net_151 n209 ssc__ratiomxh[3] n200 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu159 buft_net_151 n216 n208 n199 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu160 n199 ratiostepmxh_0 ssc__ratiomxh[4] n190 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu216 n206 ratiostepmxh_0 n200 n191 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu217 buft_net_152 n191 ssc__ratiomxh[5] n182 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu161 buft_net_152 n197 n190 n181 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu162 n181 ratiostepmxh_0 ssc__ratiomxh[6] n172 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu218 n188 ratiostepmxh_0 n182 n173 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu219 buft_net_152 n173 ssc__ratiomxh[7] n163 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu163 buft_net_152 n179 n172 n162 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu209 n262 n259 ssc__fractionmxh[21] n249 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu153 n262 n265 n258 n248 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu197 n372 n369 ssc__fractionmxh[9] n360 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu141 n372 n375 n368 n358 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu206 n293 fracstepmxh[18] n287 n278 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu204 n311 fracstepmxh[16] n305 n296 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu202 n329 fracstepmxh[14] n323 n314 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu200 n347 fracstepmxh[12] n341 n332 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu198 n366 fracstepmxh[10] n360 n350 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu151 n281 n284 n277 n267 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu150 n286 fracstepmxh[18] ssc__fractionmxh[18] n277 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu207 n281 n278 ssc__fractionmxh[19] n268 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu205 n299 n296 ssc__fractionmxh[17] n287 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu149 n299 n302 n295 n286 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu148 n304 fracstepmxh[16] ssc__fractionmxh[16] n295 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu203 n317 n314 ssc__fractionmxh[15] n305 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu147 n317 n320 n313 n304 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu152 n267 fracstepmxh[20] ssc__fractionmxh[20] n258 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu208 n274 fracstepmxh[20] n268 n259 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu146 n322 fracstepmxh[14] ssc__fractionmxh[14] n313 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu201 n335 n332 ssc__fractionmxh[13] n323 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu145 n335 n338 n331 n322 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu144 n340 fracstepmxh[12] ssc__fractionmxh[12] n331 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu199 n353 n350 ssc__fractionmxh[11] n341 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu143 n353 n356 n349 n340 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu142 n358 fracstepmxh[10] ssc__fractionmxh[10] n349 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu140 n378 fracstepmxh[8] ssc__fractionmxh[8] n368 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu196 n385 fracstepmxh[8] n379 n369 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu189 n456 n451 ssc__fractionmxh[1] n438 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu134 n436 fracstepmxh[2] ssc__fractionmxh[2] n424 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu190 n445 fracstepmxh[2] n438 n427 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu191 n430 n427 ssc__fractionmxh[3] n415 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu135 n430 n433 n424 n414 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu136 n414 fracstepmxh[4] ssc__fractionmxh[4] n405 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu192 n421 fracstepmxh[4] n415 n406 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu193 n409 n406 ssc__fractionmxh[5] n397 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu137 n409 n412 n405 n396 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu138 n396 fracstepmxh[6] ssc__fractionmxh[6] n387 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu194 n403 fracstepmxh[6] n397 n388 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu139 n391 n394 n387 n378 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu195 n391 n388 ssc__fractionmxh[7] n379 vdd vssx ringpll__b15rm6013el1n02x5 m=1
Xu315 n229 n257 buft_net_146 n228 n231 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu306 n218 buft_net_146 n257 n219 n221 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu301 n209 n257 buft_net_146 n208 n211 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu321 n239 n257 buft_net_146 n238 n242 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu293 n199 buft_net_146 n257 n200 n201 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu288 n191 n257 buft_net_146 n190 n193 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu280 n181 buft_net_146 n257 n182 n183 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu275 n173 n257 buft_net_146 n172 n175 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu327 n248 buft_net_146 n257 n249 n250 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu263 n162 buft_net_146 n257 n163 n164 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu349 n278 n257 buft_net_146 n277 n280 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu354 n286 buft_net_146 n257 n287 n288 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu362 n296 n257 buft_net_146 n295 n298 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu367 n304 buft_net_146 n257 n305 n306 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu341 n267 buft_net_146 n257 n268 n269 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu336 n259 n257 buft_net_146 n258 n261 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu375 n314 n257 buft_net_145 n313 n316 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu380 n322 buft_net_145 n257 n323 n324 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu388 n332 n257 buft_net_145 n331 n334 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu393 n340 buft_net_145 n257 n341 n342 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu401 n350 n257 buft_net_145 n349 n352 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu406 n358 buft_net_145 n257 n360 n361 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu414 n369 n257 buft_net_145 n368 n371 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu466 n453 buft_net_146 n451 n257 n455 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu458 n436 buft_net_146 n257 n438 n439 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu453 n427 n257 buft_net_146 n424 n429 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu445 n414 buft_net_145 n257 n415 n416 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu440 n406 n257 buft_net_145 n405 n408 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu432 n396 buft_net_145 n257 n397 n398 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu419 n378 buft_net_145 n257 n379 n380 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu427 n388 n257 buft_net_145 n387 n390 vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu53 cyctopeakm1mxh[4] n42 cyctopeakm1mxh[3] n33 n28 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu51 cyctopeakm1mxh[2] n26 cyctopeakm1mxh[1] n25 n29 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu19 n14 n93 n4 n89 n3 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu28 cyctopeakm1mxh[7] n59 cyctopeakm1mxh[6] n101 n7 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu40 cyctopeakm1mxh[4] n107 cyctopeakm1mxh[3] n70 n13 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu328 n249 buft_net_148 n72 n248 n251 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu320 n238 n72 buft_net_148 n239 n241 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu314 n228 n72 buft_net_148 n229 n230 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu307 n219 buft_net_148 n72 n218 n222 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu300 n208 n72 buft_net_148 n209 n210 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu294 n200 buft_net_148 n72 n199 n202 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu287 n190 n72 buft_net_148 n191 n192 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu281 n182 buft_net_148 n72 n181 n184 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu273 n172 n72 buft_net_148 n173 n174 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu413 n368 n72 buft_net_147 n369 n370 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu265 n163 buft_net_148 n72 n162 n165 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu348 n277 n72 buft_net_148 n278 n279 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu342 n268 buft_net_148 n72 n267 n270 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu355 n287 buft_net_148 n72 n286 n289 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu361 n295 n72 buft_net_148 n296 n297 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu368 n305 buft_net_148 n72 n304 n307 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu374 n313 n72 buft_net_147 n314 n315 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu334 n258 n72 buft_net_148 n259 n260 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu381 n323 buft_net_147 n72 n322 n325 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu387 n331 n72 buft_net_147 n332 n333 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu394 n341 buft_net_147 n72 n340 n343 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu400 n349 n72 buft_net_147 n350 n351 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu407 n360 buft_net_147 n72 n358 n362 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu465 n72 n453 buft_net_147 n451 n454 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu459 n438 buft_net_147 n72 n436 n440 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu452 n424 n72 buft_net_147 n427 n428 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu446 n415 buft_net_147 n72 n414 n417 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu439 n405 n72 buft_net_147 n406 n407 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu433 n397 buft_net_147 n72 n396 n399 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu426 n387 n72 buft_net_147 n388 n389 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu420 n379 buft_net_147 n72 n378 n381 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu133 n456 n453 n460 n436 vdd vssx ringpll__b15rm6013en1n04x5 m=1
Xplace_binv_r_152 ratiostepmxh_0 buft_net_152 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_151 ratiostepmxh_0 buft_net_151 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_148 n257 buft_net_148 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_147 n257 buft_net_147 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_145 n72 buft_net_145 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xu236 n86 n92 n87 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu237 n88 n87 n146 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu57 cyctopeakm1mxh[3] n33 n34 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu239 n93 n92 n94 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu243 n95 n94 n154 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu234 n89 n92 n90 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu240 n91 n90 n149 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu11 n21 n22 n20 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu7 n1 n10 n2 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu9 n5 n6 n8 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu131 fracstepmxh[0] ssc__fractionmxh[0] n453 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu71 n55 n78 n60 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu76 n78 n56 n92 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu33 n63 n48 n38 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu54 n29 n28 n30 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu25 counttopeakmxh[1] counttopeakmxh[0] n9 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu8 n2 counttopeakmxh[4] n6 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu10 counttopeakmxh[6] n8 n22 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu43 n16 n14 n93 n17 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu36 n10 n11 counttopeakmxh[2] n26 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu26 n9 counttopeakmxh[0] counttopeakmxh[1] n25 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu27 n25 n63 n14 n86 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu17 n6 counttopeakmxh[4] n2 n42 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu39 counttopeakmxh[0] n44 n63 n93 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu30 n22 n8 counttopeakmxh[6] n47 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu231 n83 ssc__ratiomxh[9] n84 n144 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu94 n65 n73 n451 n135 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu48 n23 cyctopeakm1mxh[8] n98 n53 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu55 n30 cyctopeakm1mxh[5] n32 n31 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu60 n39 cyctopeakm1mxh[7] n98 n40 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu96 n66 n67 n108 n153 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu99 n69 n108 n70 n147 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu98 n106 n108 n107 n148 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu83 n100 n108 n101 n150 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu82 n58 n108 n59 n151 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu81 n97 n108 n98 n152 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu45 n20 n22 n21 n37 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu14 n2 n10 n1 n27 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu15 n27 cyctopeakm1mxh[3] n470 n107 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu46 n37 cyctopeakm1mxh[7] n470 n98 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu22 n24 cyctopeakm1mxh[5] n470 n101 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu21 n8 n6 n5 n24 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu34 n38 cyctopeakm1mxh[8] n470 n67 vdd vssx ringpll__b15oabi12al1n03x5 m=1
Xu31 n47 cyctopeakm1mxh[6] n470 n59 vdd vssx ringpll__b15oabi12al1n03x5 m=1
Xu18 n42 n470 cyctopeakm1mxh[4] n89 vdd vssx ringpll__b15oab012al1n02x5 m=1
Xu37 n26 n12 n63 n70 vdd vssx ringpll__b15ao0012al1n02x5 m=1
Xu64 n47 n63 cyctopeakm1mxh[6] n45 vdd vssx ringpll__b15nor003al1n02x5 m=1
Xu6 counttopeakmxh[2] counttopeakmxh[1] counttopeakmxh[0] n10 vdd vssx ringpll__b15nor003al1n02x5 m=1
Xu20 n3 n4 n89 cyctopeakm1mxh[7] n59 n19 vdd vssx ringpll__b15aoi122al1n02x3 m=1
Xu29 n7 n12 n86 n70 cyctopeakm1mxh[3] n18 vdd vssx ringpll__b15aoi122al1n02x3 m=1
Xu41 n13 n101 cyctopeakm1mxh[6] n107 cyctopeakm1mxh[4] n15 vdd vssx ringpll__b15aoi122al1n02x3 m=1
Xu63 n63 counttopeakmxh[0] n44 n43 cyctopeakm1mxh[0] n46 vdd vssx ringpll__b15aoi122al1n02x3 m=1
Xu61 n41 n40 cyctopeakm1mxh[4] n42 n51 vdd vssx ringpll__b15aoi112al1n02x3 m=1
Xu65 n46 n45 n47 cyctopeakm1mxh[6] n50 vdd vssx ringpll__b15aoi112al1n02x3 m=1
Xu67 cyctopeakm1mxh[8] n48 cyctopeakm1mxh[0] n467 n49 vdd vssx ringpll__b15aboi22al1n02x3 m=1
Xu59 n37 cyctopeakm1mxh[7] n38 cyctopeakm1mxh[8] n39 vdd vssx ringpll__b15aboi22al1n02x3 m=1
Xu42 n67 n15 n12 n86 n16 vdd vssx ringpll__b15oai112al1n02x5 m=1
Xu44 n19 n18 n17 n54 vdd vssx ringpll__b15nand03al1n03x5 m=1
Xu58 ssc__directionmxh n36 n35 n34 n41 vdd vssx ringpll__b15nand04al1n02x5 m=1
Xu165 ratiostepmxh_0 ssc__directionmxh n74 vdd vssx ringpll__b15xor002al1n02x5 m=1
Xu166 n74 n71 n72 vdd vssx ringpll__b15nand02ah1n08x5 m=1
Xu170 n74 n73 n257 vdd vssx ringpll__b15norp02ah1n08x5 m=1
Xu88 n78 n220 n71 vdd vssx ringpll__b15norp02an1n03x5 m=1
Xu12 n20 counttopeakmxh[8] n63 vdd vssx ringpll__b15norp02an1n04x5 m=1
Xu78 sscenmxh n56 n103 vdd vssx ringpll__b15norp02an1n04x5 m=1
Xu32 counttopeakmxh[8] n20 n48 vdd vssx ringpll__b15and002al1n03x5 m=1
Xfracstepmxh_reg[9] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[9] net110 fracstepmxh[9] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xfracstepmxh_reg[16] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[16] net108 fracstepmxh[16] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xfracstepmxh_reg[8] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[8] net116 fracstepmxh[8] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xfracstepmxh_reg[14] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[14] net79 fracstepmxh[14] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xfracstepmxh_reg[4] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[4] net50 fracstepmxh[4] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xcyctopeakm1mxh_reg[6] ssc_mod_dfx__clkmodmxh dfx__ssc_cyc_to_peak_m1[6] net86 cyctopeakm1mxh[6] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xfracstepmxh_reg[18] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[18] net109 fracstepmxh[18] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xfracstepmxh_reg[6] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[6] net120 fracstepmxh[6] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xcyctopeakm1mxh_reg[7] ssc_mod_dfx__clkmodmxh dfx__ssc_cyc_to_peak_m1[7] net144 cyctopeakm1mxh[7] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xcyctopeakm1mxh_reg[5] ssc_mod_dfx__clkmodmxh dfx__ssc_cyc_to_peak_m1[5] net40 cyctopeakm1mxh[5] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xcyctopeakm1mxh_reg[3] ssc_mod_dfx__clkmodmxh dfx__ssc_cyc_to_peak_m1[3] net32 cyctopeakm1mxh[3] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xcyctopeakm1mxh_reg[4] ssc_mod_dfx__clkmodmxh dfx__ssc_cyc_to_peak_m1[4] net24 cyctopeakm1mxh[4] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xfracstepmxh_reg[2] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[2] net43 fracstepmxh[2] vdd vssx ringpll__b15fpn040al1n04x5 m=1
Xfracstepmxh_reg[1] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[1] net67 fracstepmxh[1] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[19] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[19] net97 fracstepmxh[19] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xcyctopeakm1mxh_reg[1] ssc_mod_dfx__clkmodmxh dfx__ssc_cyc_to_peak_m1[1] net48 cyctopeakm1mxh[1] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[20] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[20] net94 fracstepmxh[20] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[23] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[23] net92 fracstepmxh[23] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[15] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[15] net90 fracstepmxh[15] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[11] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[11] net88 fracstepmxh[11] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[21] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[21] net91 fracstepmxh[21] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[13] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[13] net83 fracstepmxh[13] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[3] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[3] net74 fracstepmxh[3] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[10] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[10] net81 fracstepmxh[10] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xsscenmxh_reg ssc_mod_dfx__clkmodmxh dfx__ssc_en net44 sscenmxh vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[5] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[5] net77 fracstepmxh[5] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[12] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[12] net85 fracstepmxh[12] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[17] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[17] net93 fracstepmxh[17] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[22] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[22] net89 fracstepmxh[22] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xcyctopeakm1mxh_reg[8] ssc_mod_dfx__clkmodmxh dfx__ssc_cyc_to_peak_m1[8] net51 cyctopeakm1mxh[8] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xcyctopeakm1mxh_reg[2] ssc_mod_dfx__clkmodmxh dfx__ssc_cyc_to_peak_m1[2] net47 cyctopeakm1mxh[2] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xcyctopeakm1mxh_reg[0] ssc_mod_dfx__clkmodmxh dfx__ssc_cyc_to_peak_m1[0] net46 cyctopeakm1mxh[0] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[7] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[7] net49 fracstepmxh[7] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xfracstepmxh_reg[0] ssc_mod_dfx__clkmodmxh dfx__fracstepnh[0] net62 fracstepmxh[0] vdd vssx ringpll__b15fpn040al1n02x3 m=1
Xratiostepmxh_reg[0] ssc_mod_dfx__clkmodmxh p0 net151 ratiostepmxh_0 vdd vssx ringpll__b15fpn040an1n08x5 m=1
Xplace_binv_r_146 n72 buft_net_146 vdd vssx ringpll__b15inv000ah1n03x5 m=1
Xu85 ssc__profupdatemxh ssc__directionmxh n63 n467 n470 n111 vdd vssx ringpll__b15aoi122an1n02x3 m=1
Xu73 ssc__profupdatemxh lockxxnnnl n56 vdd vssx ringpll__b15nanb02ah1n16x5 m=1
Xssc__directionmxh_reg ssc_mod_dfx__clkmodmxh net12 ssc__directionmxh lockxxnnnl vdd vssx ringpll__b15fqn003al1n06x5 m=1
Xu72 reg_req_ack__sscprofupdreqmxh n60 reg_req_ack__sscprofupdackmxh net340 vdd vssx ringpll__b15nonb03ah1n02x5 m=1
Xu84 reg_req_ack__ratioupdreqmxh n60 reg_req_ack__ratioupdackmxh net343 vdd vssx ringpll__b15nonb03an1n03x5 m=1
Xu227 n220 n78 n240 vdd vssx ringpll__b15nanb02ah1n08x5 m=1
Xu86 ssc__ratioupdatemxh p_abuf0 n220 vdd vssx ringpll__b15nanb02ah1n08x5 m=1
Xu92 n220 sscenmxh fracstepmxh[0] n64 vdd vssx ringpll__b15aoi012an1n02x3 m=1
Xu69 n52 ratiostepmxh_0 n54 n53 n55 vdd vssx ringpll__b15oaoi13al1n02x3 m=1
Xu90 ssc__fractionmxh[0] fracstepmxh[0] n451 vdd vssx ringpll__b15nanb02al1n02x5 m=1
Xu229 n240 ratiostepmxh_0 n81 buft_net_152 n482 n82 vdd vssx ringpll__b15oai122al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    sigma_delta_23_2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__sigma_delta_23_2 clkmodmxh lockxxnnnl reg_req_ack__mashstateresetmxh fractionmxh[22] fractionmxh[21] fractionmxh[20] fractionmxh[19] fractionmxh[18] fractionmxh[17] fractionmxh[16] fractionmxh[15] fractionmxh[14] fractionmxh[13] fractionmxh[12] fractionmxh[11] fractionmxh[10] fractionmxh[9] fractionmxh[8] fractionmxh[7] fractionmxh[6] fractionmxh[5] fractionmxh[4] fractionmxh[3] fractionmxh[2] fractionmxh[1] fractionmxh[0] errvalmxh[22] errvalmxh[21] errvalmxh[20] errvalmxh[19] errvalmxh[18] errvalmxh[17] errvalmxh[16] errvalmxh[15] errvalmxh[14] errvalmxh[13] errvalmxh[12] errvalmxh[11] errvalmxh[10] errvalmxh[9] errvalmxh[8] errvalmxh[7] errvalmxh[6] errvalmxh[5] errvalmxh[4] errvalmxh[3] errvalmxh[2] errvalmxh[1] errvalmxh[0] carrymxh vdd vssx p_abuf0 p_abuf1 p_abuf2 p_abuf3 p_abuf4 p_abuf5 p_abuf6
* .PININFO clkmodmxh:I fractionmxh[22]:I fractionmxh[21]:I fractionmxh[20]:I fractionmxh[19]:I fractionmxh[18]:I fractionmxh[17]:I fractionmxh[16]:I
* .PININFO fractionmxh[15]:I fractionmxh[14]:I fractionmxh[13]:I fractionmxh[12]:I fractionmxh[11]:I fractionmxh[10]:I fractionmxh[9]:I
* .PININFO fractionmxh[8]:I fractionmxh[7]:I fractionmxh[6]:I fractionmxh[5]:I fractionmxh[4]:I fractionmxh[3]:I fractionmxh[2]:I fractionmxh[1]:I
* .PININFO fractionmxh[0]:I lockxxnnnl:I p_abuf0:I p_abuf1:I p_abuf2:I p_abuf3:I p_abuf4:I p_abuf5:I p_abuf6:I reg_req_ack__mashstateresetmxh:I vdd:I
* .PININFO vssx:I carrymxh:O errvalmxh[22]:O errvalmxh[21]:O errvalmxh[20]:O errvalmxh[19]:O errvalmxh[18]:O errvalmxh[17]:O errvalmxh[16]:O
* .PININFO errvalmxh[15]:O errvalmxh[14]:O errvalmxh[13]:O errvalmxh[12]:O errvalmxh[11]:O errvalmxh[10]:O errvalmxh[9]:O errvalmxh[8]:O
* .PININFO errvalmxh[7]:O errvalmxh[6]:O errvalmxh[5]:O errvalmxh[4]:O errvalmxh[3]:O errvalmxh[2]:O errvalmxh[1]:O errvalmxh[0]:O
Xu25 n64 n15 n17 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu22 n11 n10 n13 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu11 fractionmxh[2] carryerrvalmxh[2] n15 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu6 fractionmxh[0] carryerrvalmxh[0] n12 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu7 fractionmxh[1] carryerrvalmxh[1] n10 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu5 fractionmxh[1] carryerrvalmxh[1] n9 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu8 n10 n9 n12 n18 vdd vssx ringpll__b15oai012an1n02x5 m=1
Xu4 fractionmxh[0] carryerrvalmxh[0] n62 vdd vssx ringpll__b15orn002al1n02x5 m=1
Xu9 fractionmxh[2] carryerrvalmxh[2] n64 vdd vssx ringpll__b15orn002al1n02x5 m=1
Xu534 errvalmxh[0] net122 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu537 errvalmxh[22] net125 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu496 errvalmxh[21] net84 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu508 errvalmxh[20] net96 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu529 errvalmxh[1] net117 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu512 errvalmxh[18] net100 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu511 errvalmxh[17] net99 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu507 errvalmxh[19] net95 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu464 errvalmxh[2] net55 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu473 errvalmxh[4] net61 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu472 errvalmxh[15] net60 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu467 errvalmxh[3] net58 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu463 errvalmxh[16] net54 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu462 errvalmxh[14] net53 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu273 errvalmxh[6] net42 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu272 errvalmxh[5] net41 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu260 errvalmxh[13] net33 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu267 errvalmxh[12] net39 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu264 errvalmxh[7] net37 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu263 errvalmxh[10] net36 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu262 errvalmxh[11] net35 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu261 errvalmxh[9] net34 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu257 errvalmxh[8] net31 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xcarryerrvalmxh_reg[20] clkmodmxh net96 carryerrvalmxh[20] p_abuf1 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[3] clkmodmxh net58 carryerrvalmxh[3] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[16] clkmodmxh net54 carryerrvalmxh[16] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[21] clkmodmxh net84 carryerrvalmxh[21] p_abuf1 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[1] clkmodmxh net117 carryerrvalmxh[1] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[18] clkmodmxh net100 carryerrvalmxh[18] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[17] clkmodmxh net99 carryerrvalmxh[17] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[19] clkmodmxh net95 carryerrvalmxh[19] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[2] clkmodmxh net55 carryerrvalmxh[2] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[4] clkmodmxh net61 carryerrvalmxh[4] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[15] clkmodmxh net60 carryerrvalmxh[15] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[8] clkmodmxh net31 carryerrvalmxh[8] p_abuf3 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[9] clkmodmxh net34 carryerrvalmxh[9] p_abuf3 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[14] clkmodmxh net53 carryerrvalmxh[14] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[6] clkmodmxh net42 carryerrvalmxh[6] p_abuf3 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[5] clkmodmxh net41 carryerrvalmxh[5] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[13] clkmodmxh net33 carryerrvalmxh[13] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[12] clkmodmxh net39 carryerrvalmxh[12] p_abuf3 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[7] clkmodmxh net37 carryerrvalmxh[7] p_abuf3 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[10] clkmodmxh net36 carryerrvalmxh[10] p_abuf3 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[11] clkmodmxh net35 carryerrvalmxh[11] p_abuf3 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[0] clkmodmxh net122 carryerrvalmxh[0] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[22] clkmodmxh net125 carryerrvalmxh[22] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xu15 n4 reg_req_ack__mashstateresetmxh carrymxh vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu67 n59 p_abuf4 errvalmxh[22] vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu65 n57 p_abuf6 errvalmxh[21] vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu29 n21 p_abuf6 errvalmxh[3] vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu27 n19 p_abuf5 errvalmxh[2] vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu24 n14 p_abuf6 errvalmxh[1] vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu12 n15 n2 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu14 n3 n20 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu21 n9 n11 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu23 n13 n12 n14 vdd vssx ringpll__b15xor002al1n02x5 m=1
Xu63 n55 p_abuf6 errvalmxh[20] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu61 n53 p_abuf6 errvalmxh[19] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu59 n51 p_abuf6 errvalmxh[18] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu57 n49 p_abuf6 errvalmxh[17] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu55 n47 p_abuf6 errvalmxh[16] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu53 n45 p_abuf5 errvalmxh[15] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu51 n43 p_abuf5 errvalmxh[14] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu49 n41 p_abuf5 errvalmxh[13] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu47 n39 p_abuf5 errvalmxh[12] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu45 n37 p_abuf5 errvalmxh[11] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu43 n35 p_abuf5 errvalmxh[10] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu41 n33 p_abuf5 errvalmxh[9] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu39 n31 p_abuf5 errvalmxh[8] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu37 n29 p_abuf5 errvalmxh[7] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu35 n27 p_abuf5 errvalmxh[6] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu33 n25 p_abuf5 errvalmxh[5] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu31 n23 p_abuf5 errvalmxh[4] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu20 n63 p_abuf6 errvalmxh[0] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu3 n62 n12 n63 vdd vssx ringpll__b15and002an1n04x5 m=1
Xu26 n18 n17 n19 vdd vssx ringpll__b15xnr002al1n02x5 m=1
Xu13 n2 n18 n64 n3 vdd vssx ringpll__b15aoi012an1n02x3 m=1
Xu66 fractionmxh[22] carryerrvalmxh[22] n58 n4 n59 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu56 fractionmxh[17] carryerrvalmxh[17] n48 n50 n49 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu52 fractionmxh[15] carryerrvalmxh[15] n44 n46 n45 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu48 fractionmxh[13] carryerrvalmxh[13] n40 n42 n41 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu42 fractionmxh[10] carryerrvalmxh[10] n34 n36 n35 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu38 fractionmxh[8] carryerrvalmxh[8] n30 n32 n31 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu28 fractionmxh[3] carryerrvalmxh[3] n20 n22 n21 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu62 fractionmxh[20] carryerrvalmxh[20] n54 n56 n55 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu60 fractionmxh[19] carryerrvalmxh[19] n52 n54 n53 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu58 fractionmxh[18] carryerrvalmxh[18] n50 n52 n51 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu54 fractionmxh[16] carryerrvalmxh[16] n46 n48 n47 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu50 fractionmxh[14] carryerrvalmxh[14] n42 n44 n43 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu46 fractionmxh[12] carryerrvalmxh[12] n38 n40 n39 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu44 fractionmxh[11] carryerrvalmxh[11] n36 n38 n37 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu40 fractionmxh[9] carryerrvalmxh[9] n32 n34 n33 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu36 fractionmxh[7] carryerrvalmxh[7] n28 n30 n29 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu34 fractionmxh[6] carryerrvalmxh[6] n26 n28 n27 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu32 fractionmxh[5] carryerrvalmxh[5] n24 n26 n25 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu30 fractionmxh[4] carryerrvalmxh[4] n22 n24 n23 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu64 fractionmxh[21] carryerrvalmxh[21] n56 n58 n57 vdd vssx ringpll__b15rm0023an1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    sync_reset_clkgen
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__sync_reset_clkgen clkrefxxh pll_fbgen__clkfbmxh reset_sync__bypassenxxnnnl earlylockxxnnnh lockxxnnnl dm_sync_reset_clkgen__clkfbgatemxh idfx_fscan_rstbypen idfx_fscan_clkungate idfx_fscan_byprstb test_si2 test_si1 test_so2 test_so1 test_sei vdd vssx p5 p45 clkrefxxl p_abuf0 p_abuf2
* .PININFO clkrefxxh:I earlylockxxnnnh:I idfx_fscan_byprstb:I idfx_fscan_clkungate:I idfx_fscan_rstbypen:I lockxxnnnl:I p5:I p45:I p_abuf2:I
* .PININFO pll_fbgen__clkfbmxh:I reset_sync__bypassenxxnnnl:I test_sei:I test_si1:I test_si2:I vdd:I vssx:I clkrefxxl:O
* .PININFO dm_sync_reset_clkgen__clkfbgatemxh:O p_abuf0:O test_so1:O test_so2:O
Xu6 sscmashclkenmxl n1 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu5 earlylockmxl n2 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu17 p_abuf2 p_abuf0 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu13 resetxxl n6 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu8 reset_sync__bypassenxxnnnl resetxxl_pre vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu3 idfx_fscan_byprstb n3 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu4 pll_fbgen__clkfbmxh clkfbmxl vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu9 idfx_fscan_rstbypen n5 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xcts_cts_dlydt_1693 clkfbmxl cts0 vdd vssx ringpll__b15cbf000ah1n02x5 m=1
Xu562 earlylockmxl net150 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu573 earlylockxxnnnh net161 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu876 net161 net310 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu903 net310 net337 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu885 net162 net319 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu828 lockxxnn1l net262 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu274 net41 test_so2 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1107 lockxxnnnl net541 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu911 net541 net345 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu574 net345 net162 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xctech_lib_doublesync_rstbsscmashclkenmxl_rccu1 cts0 p45 sscmashclkenmxl net262 p5 p45 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xctech_lib_doublesync_rstbearlylockmxl_rccu1 cts0 p45 earlylockmxl earlylockxxnn1h p5 p45 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xu12 n30 test_so1 n5 earlylockxxnn1h vdd vssx ringpll__b15aob012al1n03x5 m=1
Xu11 n30 test_so2 n5 lockxxnn1l vdd vssx ringpll__b15aob012al1n03x5 m=1
Xu16 n3 resetxxl_pre resetxxl idfx_fscan_rstbypen vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu10 idfx_fscan_rstbypen idfx_fscan_byprstb n30 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xearlylockxxnn1h_pre_reg clkrefxxh net337 test_so1 n6 test_si1 test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlockxxnn1l_pre_reg clkrefxxl net319 net41 n6 test_si2 test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xcts_cts_buf_10461788 p_abuf0 clkrefxxl vdd vssx ringpll__b15cbf000ah1n08x5 m=1
Xu7 clkfbmxl n1 pulseen1mxl n2 ctsbuf_net_7540 vdd vssx ringpll__b15oaoi13al1n03x5 m=1
Xpulseen1mxl_reg cts0 net150 pulseen1mxl vdd vssx ringpll__b15fpn000al1n02x3 m=1
Xcts_cts_buf_9581685 ctsbuf_net_7540 dm_sync_reset_clkgen__clkfbgatemxh vdd vssx ringpll__b15cbf000ah1n64x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ljpll_reset_sync
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ljpll_reset_sync clkrefxxh dfx__reset_b dfx__bypass dfx__ldo_enable_a ldo_timer[1] ldo_timer[0] reset_sync__bypassxxnnnl reset_sync__reset_b_xxnnnl reset_sync__bypassenxxnnnl idfx_fscan_rstbypen idfx_fscan_byprstb test_si test_sei vdd vssx p_abuf0 p_abuf1 p40 p51 p0
* .PININFO clkrefxxh:I dfx__bypass:I dfx__ldo_enable_a:I dfx__reset_b:I idfx_fscan_byprstb:I idfx_fscan_rstbypen:I ldo_timer[1]:I ldo_timer[0]:I p0:I
* .PININFO p40:I p51:I p_abuf0:I p_abuf1:I test_sei:I test_si:I vdd:I vssx:I reset_sync__bypassenxxnnnl:O reset_sync__bypassxxnnnl:O
* .PININFO reset_sync__reset_b_xxnnnl:O
Xu41 n24 n23 ldo_timer[1] n25 n26 vdd vssx ringpll__b15aoi112al1n02x3 m=1
Xu39 ldodly_cnt[1] ldodly_cnt[0] ldodly_cnt[6] n20 n21 vdd vssx ringpll__b15aoi112al1n02x3 m=1
Xu29 ldodly_cnt_done_sticky n14 ldodly_cnt[7] n15 ldodly_cnt_next[7] vdd vssx ringpll__b15aoi112al1n02x3 m=1
Xu21 ldodly_cnt_done_sticky n10 n9 n16 ldodly_cnt_next[4] vdd vssx ringpll__b15aoi112al1n02x3 m=1
Xu17 ldodly_cnt_done_sticky n8 n7 n20 ldodly_cnt_next[3] vdd vssx ringpll__b15aoi112al1n02x3 m=1
Xu27 ldodly_cnt_done_sticky n15 n13 n12 ldodly_cnt_next[6] vdd vssx ringpll__b15aoi112al1n02x3 m=1
Xu44 reset_sync__bypassenxxnnnl dm_sync_dfx__ldo_enable_a ldodly_cnt_rst_pre vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu9 ldodly_cnt[1] ldodly_cnt[0] n4 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu28 ldodly_cnt[7] n15 n14 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu30 ldodly_cnt_done_sticky ldodly_cnt[0] ldodly_cnt_next[0] vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu20 n16 n9 n10 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu16 n7 n20 n8 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu26 n13 n12 n15 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu4 reset_sync__bypassxxnnnl n2 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu24 n11 ldodly_cnt_next[5] vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu14 n6 ldodly_cnt_next[2] vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu3 idfx_fscan_byprstb n19 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu11 ldodly_cnt_done_sticky n28 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu31 ldodly_cnt[2] n22 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu33 ldo_timer[0] n190 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu15 ldodly_cnt[3] n20 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu19 ldodly_cnt[4] n16 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu18 n8 n9 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu25 ldodly_cnt[6] n12 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu5 n2 bypassxxnnnl n1 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu12 n5 ldodly_cnt[2] n7 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu22 n10 ldodly_cnt[5] n13 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu8 ldodly_cnt[1] ldodly_cnt[0] n5 vdd vssx ringpll__b15and002al1n03x5 m=1
Xldodly_cnt_reg[3] clkrefxxh ldodly_cnt_next[3] ldodly_cnt[3] n290 ldodly_cnt[2] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xldodly_cnt_done_sticky_reg clkrefxxh n29 ldodly_cnt_done_sticky n290 net166 p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xldodly_cnt_reg[4] clkrefxxh ldodly_cnt_next[4] ldodly_cnt[4] n290 ldodly_cnt[3] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xldodly_cnt_reg[5] clkrefxxh ldodly_cnt_next[5] ldodly_cnt[5] n290 ldodly_cnt[4] p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xldodly_cnt_reg[2] clkrefxxh ldodly_cnt_next[2] ldodly_cnt[2] n290 ldodly_cnt[1] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xldodly_cnt_reg[7] clkrefxxh ldodly_cnt_next[7] ldodly_cnt[7] n290 ldodly_cnt[6] p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xldodly_cnt_reg[6] clkrefxxh ldodly_cnt_next[6] ldodly_cnt[6] n290 ldodly_cnt[5] p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xldodly_cnt_reg[1] clkrefxxh ldodly_cnt_next[1] ldodly_cnt[1] n290 ldodly_cnt[0] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xldodly_cnt_reg[0] clkrefxxh ldodly_cnt_next[0] ldodly_cnt[0] n290 ldodly_cnt_done_sticky test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xu36 n19 ldodly_cnt_rst_pre ldodly_cnt_rst idfx_fscan_rstbypen vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu35 idfx_fscan_byprstb dfx__reset_b dfx__reset_b_postscan idfx_fscan_rstbypen vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu10 ldodly_cnt_done_sticky n5 n4 ldodly_cnt_next[1] vdd vssx ringpll__b15nor003al1n02x5 m=1
Xu6 dfx__reset_b_postscan n1 bypassxxnnnl n2 n3 vdd vssx ringpll__b15oai112al1n02x5 m=1
Xu23 n28 n13 n10 ldodly_cnt[5] n11 vdd vssx ringpll__b15oai112al1n02x5 m=1
Xu13 n28 n7 n5 ldodly_cnt[2] n6 vdd vssx ringpll__b15oai112al1n02x5 m=1
Xreset_sync__bypassxxnnnl_reg clkrefxxh bypassxxnnnl reset_sync__bypassxxnnnl dfx__reset_b_postscan ldodly_cnt[7] p_abuf0 vdd vssx ringpll__b15fqy003ah1n02x5 m=1
Xctech_lib_doublesync_rstbresetsync_b_xxnnnl_rccu1 clkrefxxh p40 reset_sync__bypassenxxnnnl resetsyncresetbnh p0 p40 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xctech_lib_doublesync_rstbbypassxxnnnl_rccu1 clkrefxxh dfx__bypass bypassxxnnnl dfx__reset_b_postscan p0 p40 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xctech_lib_doublesync_rstbsync_dfx__ldo_enable_a_rccu1 clkrefxxh dfx__ldo_enable_a dm_sync_dfx__ldo_enable_a dfx__reset_b_postscan p0 p51 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xu43 ldodly_cnt_rst n290 vdd vssx ringpll__b15inv040al1n03x5 m=1
Xu7 idfx_fscan_rstbypen n3 idfx_fscan_rstbypen n19 resetsyncresetbnh vdd vssx ringpll__b15aboi22al1n02x3 m=1
Xu40 n21 n22 ldo_timer[0] ldo_timer[1] n23 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu38 n18 n190 ldodly_cnt[4] ldodly_cnt[5] n24 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu37 n16 ldo_timer[0] ldo_timer[1] ldodly_cnt[5] n18 vdd vssx ringpll__b15oa0022al1n02x5 m=1
Xu34 ldodly_cnt[2] ldodly_cnt[6] ldodly_cnt[7] n190 n25 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu1007 test_si net441 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1113 net347 net547 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu56 net547 net22 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu57 net22 net23 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu913 net441 net347 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu59 net24 net25 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu578 net25 net166 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu58 net23 net24 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu908 n28 net342 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1109 net552 net543 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1005 net543 net439 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1075 net439 net509 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1118 net342 net552 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu907 net437 net341 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1003 net506 net437 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1105 net549 net539 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1115 net557 net549 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1123 reset_sync__bypassenxxnnnl net557 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1072 net539 net506 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu48 net341 net509 reset_sync__reset_b_xxnnnl vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu42 n28 n27 n26 n29 vdd vssx ringpll__b15aob012al1n03x5 m=1
Xu32 ldodly_cnt[7] n22 ldodly_cnt[3] ldodly_cnt[5] n27 vdd vssx ringpll__b15aoi022al1n02x3 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    lock_detector
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__lock_detector fz_lockforce fz_lockcnt[2] fz_lockcnt[1] fz_lockcnt[0] clkrefxxh dfx__openloop dfx__globalalignxxl pll_core__pfdlockrstnnnnh reset_sync__reset_b_xxnnnl reset_sync__bypassxxnnnl reset_sync__bypassenxxnnnl startup_gen__pfdenxxh tlctrl_sip__lockrstxxnnnh lock_detector__rawlockxxnnnl lock_detector__earlylockxxnnnh lockxxnnnl idfx_fscan_rstbypen idfx_fscan_clkungate idfx_fscan_byprstb test_si2 test_si1 test_so2 test_so1 test_sei vdd vssx p_abuf0 p_abuf1 p4 p44 p_abuf2 p_abuf3 p_abuf4 p_abuf5 p_abuf6 p_abuf7 p_abuf8 p_abuf9 p_abuf10 cts0 p_abuf11
* .PININFO clkrefxxh:I cts0:I dfx__globalalignxxl:I dfx__openloop:I fz_lockcnt[2]:I fz_lockcnt[1]:I fz_lockcnt[0]:I fz_lockforce:I
* .PININFO idfx_fscan_byprstb:I idfx_fscan_clkungate:I idfx_fscan_rstbypen:I p4:I p44:I p_abuf0:I p_abuf1:I p_abuf11:I pll_core__pfdlockrstnnnnh:I
* .PININFO reset_sync__bypassenxxnnnl:I reset_sync__bypassxxnnnl:I reset_sync__reset_b_xxnnnl:I startup_gen__pfdenxxh:I test_sei:I test_si1:I
* .PININFO test_si2:I tlctrl_sip__lockrstxxnnnh:I vdd:I vssx:I lock_detector__earlylockxxnnnh:O lock_detector__rawlockxxnnnl:O lockxxnnnl:O p_abuf2:O
* .PININFO p_abuf3:O p_abuf4:O p_abuf5:O p_abuf6:O p_abuf7:O p_abuf8:O p_abuf9:O p_abuf10:O test_so1:O test_so2:O
Xu26 test_so1 n11 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu42 idfx_fscan_clkungate n19 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu9 n20 n54 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu35 pllearlylockxxnnnh_rst n15 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu6 lockcntvalxxnnnh[0] n46 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu17 net360 n3 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu21 lockcntvalxxnnnh[2] n14 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu10 net459 n12 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu14 net55 n8 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu29 idfx_fscan_byprstb n57 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xplace_ainv_p_472 buf_net_407 net438 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_478 aps_rename_1430 buf_net_408 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_476 buf_net_408 p_abuf10 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_475 buf_net_408 p_abuf9 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_474 buf_net_408 p_abuf8 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_473 buf_net_408 p_abuf7 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_471 buf_net_408 p_abuf5 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_470 buf_net_408 p_abuf4 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_469 buf_net_408 p_abuf3 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_468 buf_net_408 p_abuf2 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_467 buf_net_407 lockxxnnnl vdd vssx ringpll__b15inv040an1n03x5 m=1
Xu4 n10 reset_sync__bypassxxnnnl test_so2 aps_rename_1430 vdd vssx ringpll__b15oaib12eh1n02x5 m=1
Xu3 reset_sync__bypassxxnnnl reset_sync__bypassenxxnnnl n10 vdd vssx ringpll__b15nand02ah1n06x5 m=1
Xu37 n44 dfx__openloop net352 n18 vdd vssx ringpll__b15nor003al1n02x5 m=1
Xu15 n8 n12 n13 n2 vdd vssx ringpll__b15nor003al1n02x5 m=1
Xu11 lockcntvalxxnnnh[0] lockcntvalxxnnnh[1] lockcntvalxxnnnh[2] n13 vdd vssx ringpll__b15nandp3an1n03x5 m=1
Xu30 n12 n11 n55 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu38 startup_gen__pfdenxxh n18 lockcntrstnnnnh_pre vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu7 lockcntvalxxnnnh[0] lockcntvalxxnnnh[1] n17 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu923 net357 net33 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu266 net33 test_so1 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu815 net26 net249 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu60 net5 net26 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu818 net278 net252 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu570 lockcnttripxxnnnh net158 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1084 net158 net518 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu55 net20 net21 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu576 net21 net164 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu912 net346 net440 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1074 net440 net508 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1133 net154 net567 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu826 net6 net260 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu57 reset_sync__reset_b_xxnnnl net6 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu920 net449 net354 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu850 net354 net284 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu851 net284 net285 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1015 net518 net449 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu952 rawlocknnnnl net386 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu273 net386 net40 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1063 net40 net497 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu268 net542 net35 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1128 net35 net562 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1125 net562 net559 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1006 net508 net542 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1108 net551 lock_detector__rawlockxxnnnl vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1117 net559 net551 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu566 n54 net154 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu56 n15 net5 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu847 n16 net281 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1004 net438 p_abuf6 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu833 net266 net267 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu832 net250 net266 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu816 net278 net250 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu834 net267 net268 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu49 net14 net15 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu48 net13 net14 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu47 net12 net13 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu577 net15 net165 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu45 net10 net11 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu41 net369 net10 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu935 net462 net369 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu46 net11 net12 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1096 net9 net530 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu40 net8 net9 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu39 test_si1 net8 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1028 net530 net462 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu844 net279 net278 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu845 net280 net279 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu846 net281 net280 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu821 net278 net255 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu829 net255 net263 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu830 net263 net264 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu831 net264 net265 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu820 net278 net254 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu819 net278 net253 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu817 net278 net251 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu52 net371 net18 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu53 net18 net19 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu54 net19 net20 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu50 net40 net16 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu51 net16 net17 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu937 net17 net371 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu922 n11 net356 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu265 aps_rename_1430 net32 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu918 stkylockcntrstnnnnh_pre net352 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu824 lockcntvalxxnnnh[4] net55 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1025 lockcntvalxxnnnh[3] net459 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu926 lockcntvalxxnnnh[5] net360 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu28 tlctrl_sip__lockrstxxnnnh reset_sync__reset_b_xxnnnl stkylockcntrstnnnnh_pre vdd vssx ringpll__b15nanb02al1n02x5 m=1
Xplace_ainv_p_477 net32 buf_net_407 vdd vssx ringpll__b15inv000ah1n03x5 m=1
Xu27 n10 reset_sync__bypassxxnnnl net356 lock_detector__earlylockxxnnnh vdd vssx ringpll__b15oai012an1n02x5 m=1
Xu19 fz_lockcnt[0] n12 fz_lockcnt[1] n3 n4 vdd vssx ringpll__b15aoi022al1n02x3 m=1
Xu8 n17 lockcntvalxxnnnh[0] lockcntvalxxnnnh[1] n47 vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xlockcntvalxxnnnh_reg[0] ctsbuf_net_11544 n46 lockcntvalxxnnnh[0] net268 net165 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xpllearlylockxxnnnh_reg ctsbuf_net_11544 n55 net357 net249 net360 p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlockcntvalxxnnnh_reg[1] ctsbuf_net_11544 n47 lockcntvalxxnnnh[1] net251 lockcntvalxxnnnh[0] p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlockcntvalxxnnnh_reg[3] ctsbuf_net_11544 n49 lockcntvalxxnnnh[3] net253 lockcntvalxxnnnh[2] p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlockcntvalxxnnnh_reg[2] ctsbuf_net_11544 n48 lockcntvalxxnnnh[2] net252 lockcntvalxxnnnh[1] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlockcntvalxxnnnh_reg[5] ctsbuf_net_11544 n51 lockcntvalxxnnnh[5] net265 net55 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlockcntvalxxnnnh_reg[4] ctsbuf_net_11544 n50 lockcntvalxxnnnh[4] net254 net459 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xu23 fz_lockcnt[1] fz_lockcnt[0] n5 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu44 lock_detector__rawlockxxnnnl test_so2 n20 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu12 n12 n13 n1 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu43 p_abuf11 n19 net497 clklockcntxxh vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu13 n1 n12 n13 n49 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu16 n2 n8 n12 n13 n50 vdd vssx ringpll__b15oaoi13al1n02x3 m=1
Xu18 n2 n3 net360 n2 n51 vdd vssx ringpll__b15aboi22al1n02x3 m=1
Xu5 fz_lockforce p_abuf6 n42 vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu33 p4 pll_core__pfdlockrstnnnnh n44 n42 vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu32 n57 net352 pllearlylockxxnnnh_rst idfx_fscan_rstbypen vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu31 n57 lockcntrstnnnnh_pre lockcntvalxxnnnh_rst idfx_fscan_rstbypen vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu36 lockcntvalxxnnnh_rst n16 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xcts_cts_buf_10261768 clklockcntxxh ctsbuf_net_11544 vdd vssx ringpll__b15cbf000ah1n02x5 m=1
Xrawlocknnnnl_reg clkrefxxh net285 rawlocknnnnl vdd vssx ringpll__b15lsn080al1n02x3 m=1
Xplllockxxnnnl_reg clkrefxxh net567 test_so2 p44 net260 test_si2 test_sei vdd vssx ringpll__b15fqy08fal1n04x5 m=1
Xctech_lib_doublesync_rstblock_detector__rawlockxxnnnl_rccu1 cts0 net164 net346 reset_sync__reset_b_xxnnnl p4 p44 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xu25 fz_lockcnt[2] n9 n8 n7 lockcnttripxxnnnh vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu20 n4 fz_lockcnt[1] net55 n9 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu22 fz_lockcnt[1] n13 fz_lockcnt[0] n14 n6 vdd vssx ringpll__b15oai112al1n02x5 m=1
Xu24 net360 n5 net459 n6 n7 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu34 n13 n17 n14 n48 vdd vssx ringpll__b15aobi12al1n02x3 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    tlctrl_sip
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__tlctrl_sip clkrefxxh reset_sync__reset_b_xxnnnl dfx__tllm_en lock_detector__earlylockxxnnnh tlctrl_sip__lockrstxxnnnh tlctrl_sip__statexxnnnh[1] tlctrl_sip__statexxnnnh[0] tlctrl_sip__tightloopxxnnnh tlctrl_sip__gateclkdistxxnnnl earlylockxxnnnh idfx_fscan_clkungate test_si test_so test_sei vdd vssx p_abuf0 p_abuf1
* .PININFO clkrefxxh:I dfx__tllm_en:I idfx_fscan_clkungate:I lock_detector__earlylockxxnnnh:I p_abuf0:I p_abuf1:I reset_sync__reset_b_xxnnnl:I
* .PININFO test_sei:I test_si:I vdd:I vssx:I earlylockxxnnnh:O test_so:O tlctrl_sip__gateclkdistxxnnnl:O tlctrl_sip__lockrstxxnnnh:O
* .PININFO tlctrl_sip__statexxnnnh[1]:O tlctrl_sip__statexxnnnh[0]:O tlctrl_sip__tightloopxxnnnh:O
Xu8 test_so n7 n9 vdd vssx ringpll__b15orn002al1n02x5 m=1
Xu19 n9 n8 n16 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu18 n7 n8 n14 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu7 tlctrl_sip__statexxnnnh[0] n5 n7 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu6 tlctrl_sip__lockrstxxnnnh tlctrl_sip__statexxnnnh[1] n5 vdd vssx ringpll__b15and002al1n03x5 m=1
Xu5 tlctrl_sip__statexxnnnh[1] tlctrl_sip__lockrstxxnnnh n6 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu3 tlctrl_sip__statexxnnnh[0] tlctrl_sip__tightloopxxnnnh vdd vssx ringpll__b15bfn000al1n02x5 m=1
Xu16 n9 test_so n7 n17 vdd vssx ringpll__b15aob012al1n03x5 m=1
Xstatexxnnnh_reg[0] clkrefgatexxh n15 tlctrl_sip__statexxnnnh[0] reset_sync__reset_b_xxnnnl net536 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xwaitcntxxnnnh_reg[0] clkrefgatexxh n17 test_so reset_sync__reset_b_xxnnnl tlctrl_sip__lockrstxxnnnh test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xstatexxnnnh_reg[1] clkrefgatexxh net289 tlctrl_sip__statexxnnnh[1] reset_sync__reset_b_xxnnnl tlctrl_sip__statexxnnnh[0] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xstatexxnnnh_reg[2] clkrefgatexxh net291 net355 reset_sync__reset_b_xxnnnl tlctrl_sip__statexxnnnh[1] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xu21 p_abuf1 idfx_fscan_clkungate reset_sync__reset_b_xxnnnl clockenxxnnnl n10 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu10 net377 n3 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu11 net502 n2 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu14 lock_detector__earlylockxxnnnh n4 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu22 n10 clkrefgatexxh vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu921 net355 net39 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu272 net39 tlctrl_sip__lockrstxxnnnh vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu857 net290 net291 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu572 net2 net160 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu2 n16 net2 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu856 net160 net290 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu302 tlctrl_sip__statexxnnnh[1] net43 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu943 net43 net377 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu925 tlctrl_sip__statexxnnnh[0] net359 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1068 net359 net502 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu579 test_si net167 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu949 net167 net383 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1037 net383 net471 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1102 net471 net536 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1 n14 net1 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu854 net159 net288 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu855 net288 net289 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu571 net1 net159 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu583 clockenxxnnnh net171 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xclockenxxnnnl_reg clkrefxxh net171 clockenxxnnnl vdd vssx ringpll__b15lsn080al1n02x3 m=1
Xu17 lock_detector__earlylockxxnnnh tlctrl_sip__statexxnnnh[0] n6 n8 vdd vssx ringpll__b15nand03al1n03x5 m=1
Xu15 n4 tlctrl_sip__statexxnnnh[0] n6 n5 earlylockxxnnnh vdd vssx ringpll__b15oaoi13al1n02x3 m=1
Xu9 n6 n9 n15 vdd vssx ringpll__b15nanb02al1n02x5 m=1
Xu12 tlctrl_sip__lockrstxxnnnh dfx__tllm_en n3 n1 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu13 n2 n1 dfx__tllm_en n3 clockenxxnnnh vdd vssx ringpll__b15oai112al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    reg_req_ack
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__reg_req_ack ssc_mod_dfx__clkmodmxh lockxxnnnl dfx__disable_run_upd dfx__ratio_update_req dfx__ssc_prof_update_req ssc__profupdatemxh ssc__ratioupdatemxh reg_req_ack__sscprofupdreqmxh reg_req_ack__sscprofupdackmxh reg_req_ack__ratioupdreqmxh reg_req_ack__ratioupdackmxh reg_req_ack__mashstateresetmxh vdd vssx p0 p_abuf0 p_abuf1 p_abuf2 p_abuf3 p1
* .PININFO dfx__disable_run_upd:I dfx__ratio_update_req:I dfx__ssc_prof_update_req:I lockxxnnnl:I p0:I p1:I p_abuf3:I ssc__profupdatemxh:I
* .PININFO ssc__ratioupdatemxh:I ssc_mod_dfx__clkmodmxh:I vdd:I vssx:I p_abuf0:O p_abuf1:O p_abuf2:O reg_req_ack__mashstateresetmxh:O
* .PININFO reg_req_ack__ratioupdackmxh:O reg_req_ack__ratioupdreqmxh:O reg_req_ack__sscprofupdackmxh:O reg_req_ack__sscprofupdreqmxh:O
Xplace_ainv_p_484 buf_net_415 p_abuf2 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_483 buf_net_415 p_abuf1 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_482 buf_net_415 p_abuf0 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_481 buf_net_415 reg_req_ack__mashstateresetmxh vdd vssx ringpll__b15inv040an1n03x5 m=1
Xreg_req_ack__ratioupdackmxh_reg ssc_mod_dfx__clkmodmxh n0 reg_req_ack__ratioupdackmxh lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xreg_req_ack__sscprofupdackmxh_reg ssc_mod_dfx__clkmodmxh n1 reg_req_ack__sscprofupdackmxh lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xu7 reg_req_ack__sscprofupdreqmxh ssc__profupdatemxh reg_req_ack__sscprofupdackmxh n2 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu5 reg_req_ack__ratioupdreqmxh ssc__ratioupdatemxh reg_req_ack__ratioupdackmxh n10 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu6 n2 n1 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu4 n10 n0 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xctech_lib_doublesync_rstbsscprofupdreqmxh_rccu1 ssc_mod_dfx__clkmodmxh p0 net3 lockxxnnnl p0 p1 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xctech_lib_doublesync_rstbratioupdreqmxh_rccu1 p_abuf3 p0 reg_req_ack__ratioupdreqmxh lockxxnnnl p0 p1 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xu9 ssc__ratioupdatemxh ssc__profupdatemxh aps_rename_1431 vdd vssx ringpll__b15orn002al1n02x5 m=1
Xplace_ainv_p_485 aps_rename_1431 buf_net_415 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xu3 net3 reg_req_ack__sscprofupdreqmxh vdd vssx ringpll__b15bfn001al1n06x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_ctl
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_ctl clkrefxxh dfx__adc_start dfx__adc_start_cnt[1] dfx__adc_start_cnt[0] adc_ctl__startxxh adc_ctl__reset_bxxl idfx_fscan_rstbypen idfx_fscan_clkungate idfx_fscan_byprstb test_si test_so test_sei vdd vssx p_abuf0 p2 p12 cts0 p_abuf1
* .PININFO clkrefxxh:I cts0:I dfx__adc_start:I dfx__adc_start_cnt[1]:I dfx__adc_start_cnt[0]:I idfx_fscan_byprstb:I idfx_fscan_clkungate:I
* .PININFO idfx_fscan_rstbypen:I p2:I p12:I p_abuf0:I p_abuf1:I test_sei:I test_si:I vdd:I vssx:I adc_ctl__reset_bxxl:O adc_ctl__startxxh:O test_so:O
Xu8 adccountxxh_1 adccountxxh_0 n3 vdd vssx ringpll__b15and002al1n03x5 m=1
Xu10 adccountxxh_0 adccountxxh_1 adccountxxh_2 n4 vdd vssx ringpll__b15and003al1n02x5 m=1
Xu32 idfx_fscan_clkungate n140 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu25 adccountxxh_5 n130 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu4 idfx_fscan_rstbypen n150 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu24 adc_ctl__reset_bxxl resetxxl_pre vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu7 adccountxxh_0 n9 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu20 adccountxxh_6 n100 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu14 adccountxxh_4 n5 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu3 idfx_fscan_byprstb n7 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu5 n150 dfx__adc_start n1 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu18 adccountxxh_5 n8 n90 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu12 n4 adccountxxh_3 n70 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu21 n100 n90 n110 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu15 n5 n70 n8 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu11 n4 n3 adccountxxh_2 n11 vdd vssx ringpll__b15oab012al1n02x5 m=1
Xu9 n3 adccountxxh_0 adccountxxh_1 n10 vdd vssx ringpll__b15oab012al1n02x5 m=1
Xadccountxxh_reg[2] cts1 n11 adccountxxh_2 n160 adccountxxh_1 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xadccountxxh_reg[3] cts1 n12 adccountxxh_3 n160 adccountxxh_2 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xadccountxxh_reg[5] cts1 n14 adccountxxh_5 n160 adccountxxh_4 test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xadccountxxh_reg[0] cts1 n9 adccountxxh_0 n160 test_si p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xadccountxxh_reg[6] cts1 n15 adccountxxh_6 n160 adccountxxh_5 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xadccountxxh_reg[4] cts1 n13 adccountxxh_4 n160 adccountxxh_3 test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xadccountxxh_reg[1] cts1 n10 adccountxxh_1 n160 adccountxxh_0 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xadccountxxh_reg[7] cts1 n16 net358 n160 adccountxxh_6 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xu19 n90 adccountxxh_5 n8 n14 vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu13 n70 n4 adccountxxh_3 n12 vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu17 n8 n70 n5 n13 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu22 n110 n100 n90 n15 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xctech_lib_doublesync_rstbdfxadcstartxxl_rccu1 cts0 p12 adc_ctl__reset_bxxl dfx__adc_start_postscan p2 p12 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xu6 n1 n150 n7 dfx__adc_start_postscan vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu28 resetxxl n160 vdd vssx ringpll__b15inv040al1n03x5 m=1
Xu16 n7 resetxxl_pre resetxxl idfx_fscan_rstbypen vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu27 n120 dfx__adc_start_cnt[0] n130 adc_ctl__startxxh vdd vssx ringpll__b15aoi012ah1n02x5 m=1
Xu26 dfx__adc_start_cnt[1] adccountxxh_6 dfx__adc_start_cnt[1] test_so n120 vdd vssx ringpll__b15aboi22al1n02x3 m=1
Xu978 adcstartxxl net412 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1021 net412 net455 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1087 net455 net521 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu924 net358 test_so vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1012 net353 net446 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1111 net555 net545 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1079 net545 net513 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu919 net513 net353 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu569 adc_ctl__startxxh net157 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu821 net157 net52 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1121 net52 net555 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xadcstartxxl_reg clkrefxxh net446 adcstartxxl vdd vssx ringpll__b15lsn080al1n02x3 m=1
Xu23 test_so n110 n16 vdd vssx ringpll__b15xor002al1n02x5 m=1
Xu33 p_abuf1 n140 net521 resetxxl_pre clkadccountxxh vdd vssx ringpll__b15oaoi13al1n02x3 m=1
Xcts_cto_buf_drc_1871 clkadccountxxh cts1 vdd vssx ringpll__b15cbf000ah1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vctl_trim_fsm
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vctl_trim_fsm clkrefxxh reset_sync__reset_b_xxnnnl dfx__openloop startup_gen__vctltrimenxxh startup_gen__forcepullupxxh iref_ctrl__irefdonexxh pll_core__compoutnnnnh vctl_trim_fsm__vctlrdacshortxxh vctl_trim_fsm__trimdonexxh vctl_trim_fsm__cmpenxxh vctl_trim_fsm__pullupnnnnh vctl_trim_fsm__pulldnnnnnh idfx_fscan_rstbypen idfx_fscan_byprstb test_si test_so test_sei vdd vssx p_abuf0 p_abuf1 p_abuf2 p62 p13
* .PININFO clkrefxxh:I dfx__openloop:I idfx_fscan_byprstb:I idfx_fscan_rstbypen:I iref_ctrl__irefdonexxh:I p13:I p62:I p_abuf0:I p_abuf1:I p_abuf2:I
* .PININFO pll_core__compoutnnnnh:I reset_sync__reset_b_xxnnnl:I startup_gen__forcepullupxxh:I startup_gen__vctltrimenxxh:I test_sei:I test_si:I vdd:I
* .PININFO vssx:I test_so:O vctl_trim_fsm__cmpenxxh:O vctl_trim_fsm__pulldnnnnnh:O vctl_trim_fsm__pullupnnnnh:O vctl_trim_fsm__trimdonexxh:O
* .PININFO vctl_trim_fsm__vctlrdacshortxxh:O
Xctech_lib_doublesync_rstbtrimdonexxh_b_rccu1 clkrefxxh ctech_lib_doublesync_rstbtrimdonexxh_b_d trimdonexxh_b reset_sync__reset_b_xxnnnl p13 p62 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xu12 n5 trimdonenh_b ctech_lib_doublesync_rstbtrimdonexxh_b_d vdd vssx ringpll__b15orn002al1n02x5 m=1
Xu6 pullupmodeflopxxh forcedonesetflopxxh n1 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu26 trimfsmstatexxh_0 n10 pullupmodexxh vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu25 test_so n9 pulldnmodexxh vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu7 n5 forcedonesetxxh n4 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu4 pulldnmodeflopxxh pullupmodeflopxxh n8 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu24 trimdonexxh_b n8 vctl_trim_fsm__vctlrdacshortxxh vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu11 n9 n10 n5 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu27 trimdonesetnh n11 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu8 idfx_fscan_byprstb n30 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu18 trimdonexxh_b n6 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu14 n2 forcedonesetxxh vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu10 test_so n10 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu15 forcedonesetxxh n33 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu9 trimfsmstatexxh_0 n9 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu5 reset_sync__reset_b_xxnnnl n1 trimdonesetnh_pre vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu19 trimfsmstatexxh_0 n7 trimfsmnxtstatexxh[1] vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu17 test_so n4 trimfsmnxtstatexxh[0] vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu13 n9 n10 n2 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xtrimdonenh_b_reg clkrefxxh ctech_lib_doublesync_rstbtrimdonexxh_b_d trimdonenh_b n11 pullupmodeflopxxh test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xpulldnmodeflopxxh_reg clkrefxxh pulldnmodexxh pulldnmodeflopxxh reset_sync__reset_b_xxnnnl forcedonesetflopxxh p_abuf2 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xu16 n6 forcedonesetxxh n5 forcedonesetxxh n7 vdd vssx ringpll__b15oai022al1n02x3 m=1
Xu1032 net376 net466 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu942 net163 net376 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu575 test_si net163 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1095 net466 net529 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xforcedonesetflopxxh_reg clkrefxxh forcedonesetxxh forcedonesetflopxxh reset_sync__reset_b_xxnnnl net529 p_abuf1 vdd vssx ringpll__b15fqy00cal1n02x3 m=1
Xtrimfsmstatexxh_reg[1] clkrefxxh trimfsmnxtstatexxh[1] n33 test_so reset_sync__reset_b_xxnnnl trimfsmstatexxh_0 p_abuf1 vdd vssx ringpll__b15fqy043al1n02x5 m=1
Xtrimfsmstatexxh_reg[0] clkrefxxh trimfsmnxtstatexxh[0] n33 trimfsmstatexxh_0 reset_sync__reset_b_xxnnnl trimdonenh_b p_abuf0 vdd vssx ringpll__b15fqy043al1n02x5 m=1
Xpullupmodeflopxxh_reg clkrefxxh pullupmodexxh pullupmodeflopxxh reset_sync__reset_b_xxnnnl pulldnmodeflopxxh p_abuf0 vdd vssx ringpll__b15fqy003al1n02x5 m=1
Xu30 n30 trimdonesetnh_pre trimdonesetnh idfx_fscan_rstbypen vdd vssx ringpll__b15cmbn22al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    unlock_counter
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__unlock_counter clkrefxxh reset_sync__reset_b_xxnnnl lockxxnnnl lock_detector__rawlockxxnnnl idfx_fscan_clkungate unlock_counter__unlockcountxxnnnh[1] unlock_counter__unlockcountxxnnnh[0] test_si3 test_si2 test_si1 test_so1 test_sei vdd vssx p_abuf0 p_abuf1 p_abuf2 p0
* .PININFO clkrefxxh:I idfx_fscan_clkungate:I lock_detector__rawlockxxnnnl:I lockxxnnnl:I p0:I p_abuf0:I p_abuf1:I p_abuf2:I
* .PININFO reset_sync__reset_b_xxnnnl:I test_sei:I test_si1:I test_si2:I test_si3:I vdd:I vssx:I test_so1:O unlock_counter__unlockcountxxnnnh[1]:O
* .PININFO unlock_counter__unlockcountxxnnnh[0]:O
Xu5 unlock_counter__unlockcountxxnnnh[1] unlock_counter__unlockcountxxnnnh[0] n6 vdd vssx ringpll__b15and002al1n03x5 m=1
Xunlock_counter__unlockcountxxnnnh_reg[1] clkunlockxxh n4 unlock_counter__unlockcountxxnnnh[1] reset_sync__reset_b_xxnnnl net494 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x5 m=1
Xunlock_counter__unlockcountxxnnnh_reg[0] clkunlockxxh n3 unlock_counter__unlockcountxxnnnh[0] reset_sync__reset_b_xxnnnl net495 test_sei vdd vssx ringpll__b15fqy003al1n02x5 m=1
Xu1124 net550 net558 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1077 net442 net511 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1008 net544 net442 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu825 net2 net259 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu2 net74 net2 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu843 reset_sync__reset_b_xxnnnl net74 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu827 reset_sync__reset_b_xxnnnl net261 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1106 net344 net540 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu910 net563 net344 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1129 net153 net563 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1116 net540 net550 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1119 net560 net553 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1126 net564 net560 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1130 net566 net564 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1110 net553 net544 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1135 net349 net569 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu915 net152 net349 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu564 test_si2 net152 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1132 net569 net566 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1 n1 net1 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu565 net1 net153 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1045 net375 net479 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu941 net170 net375 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu582 n6 net170 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu581 test_si1 net169 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1061 net405 net495 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu971 net169 net405 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1060 net404 net494 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu970 net168 net404 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu580 test_si3 net168 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu6 n6 unlock_counter__unlockcountxxnnnh[0] unlock_counter__unlockcountxxnnnh[1] n4 vdd vssx ringpll__b15oab012al1n02x5 m=1
Xu11 n2 clkunlockxxh vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu4 unlock_counter__unlockcountxxnnnh[0] n3 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xcountersatxxnnnl_reg clkrefxxh net479 countersatxxnnnl vdd vssx ringpll__b15lsn080al1n02x3 m=1
Xu9 countersatxxnnnl test_so1 n10 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu10 p_abuf2 idfx_fscan_clkungate unlockxxnn0l n10 n2 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu3 lockxxnnnl lock_detector__rawlockxxnnnl n1 vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xunlockxxnn0l_reg clkrefxxh net558 unlockxxnn0l p0 net259 net511 p_abuf1 vdd vssx ringpll__b15fqy08fal1n02x5 m=1
Xunlockxxnn1l_reg clkrefxxh unlockxxnn0l test_so1 p0 net261 unlockxxnn0l p_abuf1 vdd vssx ringpll__b15fqy08fal1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    lock_timer
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__lock_timer clkrefxxh reset_sync__reset_b_xxnnnl lockxxnnnl lock_timer__locktimecntxxnnnh[11] lock_timer__locktimecntxxnnnh[10] lock_timer__locktimecntxxnnnh[9] lock_timer__locktimecntxxnnnh[8] lock_timer__locktimecntxxnnnh[7] lock_timer__locktimecntxxnnnh[6] lock_timer__locktimecntxxnnnh[5] lock_timer__locktimecntxxnnnh[4] lock_timer__locktimecntxxnnnh[3] lock_timer__locktimecntxxnnnh[2] lock_timer__locktimecntxxnnnh[1] lock_timer__locktimecntxxnnnh[0] idfx_fscan_clkungate test_si2 test_si1 test_sei vdd vssx p_abuf0 p_abuf1 p_abuf2
* .PININFO clkrefxxh:I idfx_fscan_clkungate:I lockxxnnnl:I p_abuf0:I p_abuf1:I p_abuf2:I reset_sync__reset_b_xxnnnl:I test_sei:I test_si1:I test_si2:I
* .PININFO vdd:I vssx:I lock_timer__locktimecntxxnnnh[11]:O lock_timer__locktimecntxxnnnh[10]:O lock_timer__locktimecntxxnnnh[9]:O
* .PININFO lock_timer__locktimecntxxnnnh[8]:O lock_timer__locktimecntxxnnnh[7]:O lock_timer__locktimecntxxnnnh[6]:O lock_timer__locktimecntxxnnnh[5]:O
* .PININFO lock_timer__locktimecntxxnnnh[4]:O lock_timer__locktimecntxxnnnh[3]:O lock_timer__locktimecntxxnnnh[2]:O lock_timer__locktimecntxxnnnh[1]:O
* .PININFO lock_timer__locktimecntxxnnnh[0]:O
Xu4 lock_timer__locktimecntxxnnnh[0] n1 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu24 lock_timer__locktimecntxxnnnh[9] n110 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu9 lock_timer__locktimecntxxnnnh[3] n20 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu14 lock_timer__locktimecntxxnnnh[5] n50 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu19 lock_timer__locktimecntxxnnnh[7] n80 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu29 lock_timer__locktimecntxxnnnh[11] n14 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu10 n30 n20 n40 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu15 n50 n60 n70 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu20 n80 n90 n100 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu25 n110 n120 n131 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu30 n14 n15 n24 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu12 n40 lock_timer__locktimecntxxnnnh[4] n60 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu17 n70 lock_timer__locktimecntxxnnnh[6] n90 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu22 n100 lock_timer__locktimecntxxnnnh[8] n120 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu27 n131 lock_timer__locktimecntxxnnnh[10] n15 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu7 lock_timer__locktimecntxxnnnh[0] lock_timer__locktimecntxxnnnh[1] lock_timer__locktimecntxxnnnh[2] n30 vdd vssx ringpll__b15nand03al1n03x5 m=1
Xu5 lock_timer__locktimecntxxnnnh[1] n1 n130 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu11 n40 n30 n20 n4 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu16 n70 n60 n50 n6 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu21 n100 n90 n80 n8 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu26 n131 n120 n110 n10 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu31 n24 n15 n14 n12 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[2] ctsbuf_net_10543 n3 lock_timer__locktimecntxxnnnh[2] reset_sync__reset_b_xxnnnl net321 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[7] ctsbuf_net_10543 n8 lock_timer__locktimecntxxnnnh[7] reset_sync__reset_b_xxnnnl lock_timer__locktimecntxxnnnh[6] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[1] ctsbuf_net_10543 n2 lock_timer__locktimecntxxnnnh[1] reset_sync__reset_b_xxnnnl lock_timer__locktimecntxxnnnh[0] p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[3] ctsbuf_net_10543 n4 lock_timer__locktimecntxxnnnh[3] reset_sync__reset_b_xxnnnl lock_timer__locktimecntxxnnnh[2] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[4] ctsbuf_net_10543 n5 lock_timer__locktimecntxxnnnh[4] reset_sync__reset_b_xxnnnl lock_timer__locktimecntxxnnnh[3] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[5] ctsbuf_net_10543 n6 lock_timer__locktimecntxxnnnh[5] reset_sync__reset_b_xxnnnl lock_timer__locktimecntxxnnnh[4] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[6] ctsbuf_net_10543 n7 lock_timer__locktimecntxxnnnh[6] reset_sync__reset_b_xxnnnl lock_timer__locktimecntxxnnnh[5] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[0] ctsbuf_net_10543 n1 lock_timer__locktimecntxxnnnh[0] reset_sync__reset_b_xxnnnl net322 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[8] ctsbuf_net_10543 n9 lock_timer__locktimecntxxnnnh[8] reset_sync__reset_b_xxnnnl lock_timer__locktimecntxxnnnh[7] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[9] ctsbuf_net_10543 n10 lock_timer__locktimecntxxnnnh[9] reset_sync__reset_b_xxnnnl lock_timer__locktimecntxxnnnh[8] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[10] ctsbuf_net_10543 n11 lock_timer__locktimecntxxnnnh[10] reset_sync__reset_b_xxnnnl lock_timer__locktimecntxxnnnh[9] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_timer__locktimecntxxnnnh_reg[11] ctsbuf_net_10543 n12 lock_timer__locktimecntxxnnnh[11] reset_sync__reset_b_xxnnnl lock_timer__locktimecntxxnnnh[10] test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xu8 n30 n130 lock_timer__locktimecntxxnnnh[2] n3 vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu34 p_abuf2 idfx_fscan_clkungate n16 clklockcntxxh vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu13 n60 n40 lock_timer__locktimecntxxnnnh[4] n5 vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu18 n90 n70 lock_timer__locktimecntxxnnnh[6] n7 vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu23 n120 n100 lock_timer__locktimecntxxnnnh[8] n9 vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu28 n15 n131 lock_timer__locktimecntxxnnnh[10] n11 vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu6 n130 lock_timer__locktimecntxxnnnh[0] lock_timer__locktimecntxxnnnh[1] n2 vdd vssx ringpll__b15oab012al1n02x5 m=1
Xcountsatxxnnnl_reg clkrefxxh net430 countsatxxnnnl vdd vssx ringpll__b15lsn080al1n02x3 m=1
Xu888 net274 net322 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu840 net273 net274 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu839 net477 net273 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu846 net272 net77 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu838 net156 net272 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu568 test_si1 net156 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1043 net77 net477 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu269 test_si2 net36 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1014 net36 net448 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu845 net448 net76 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu835 net155 net269 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu836 net269 net270 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu837 net270 net271 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu567 net76 net155 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu887 net271 net321 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu996 net173 net430 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu585 n24 net173 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xcts_cts_buf_10071749 clklockcntxxh ctsbuf_net_10543 vdd vssx ringpll__b15cbf000ah1n04x5 m=1
Xu33 reset_sync__reset_b_xxnnnl countsatxxnnnl lockxxnnnl n16 vdd vssx ringpll__b15nonb03an1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    clk2to1mux_0
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__clk2to1mux_0 ckmuxout ckin1 ckin2 muxselect vdd vssx p_abuf0
* .PININFO ckin1:I ckin2:I muxselect:I vdd:I vssx:I ckmuxout:O p_abuf0:O
Xu1 ckin1 n1 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xcts_cts_buf_5151213 p_abuf0 ckmuxout vdd vssx ringpll__b15cbf000ah1n02x5 m=1
Xu2 muxselect ckin2 muxselect n1 p_abuf0 vdd vssx ringpll__b15naoai3en1n08x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    clk2to1mux_1
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__clk2to1mux_1 ckmuxout ckin1 ckin2 muxselect vdd vssx
* .PININFO ckin1:I ckin2:I muxselect:I vdd:I vssx:I ckmuxout:O
Xu1 ckin1 n1 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu2 muxselect ckin2 muxselect n1 ckmuxout vdd vssx ringpll__b15naoai3en1n12x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_tlctrl_hip
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_tlctrl_hip gate_gridclkb tctrl_tight_loopb clkpll clkpostdist fz_tightloop reset_b tllm_force_tight_loop vccpll vssx
* .PININFO clkpll:I clkpostdist:I fz_tightloop:I reset_b:I tllm_force_tight_loop:I vccpll:I vssx:I gate_gridclkb:O tctrl_tight_loopb:O
Xnor00 tllm_force_tight_loop n1 tctrl_tight_loopb vccpll vssx ringpll__b15nor002al1n08x5 m=1
Xfmy21 clkpost_b n1 gate_gridclk rb vccpll vccpll vccpll vssx ringpll__b15fmy203al1n04x5 m=1
Xfmy20 clkpll_b tftl n1 rb vccpll vccpll vccpll vssx ringpll__b15fmy203al1n04x5 m=1
Xnand1 clkpostdist fz_tightloopb clkpost_b vccpll vssx ringpll__b15nand02al1n16x5 m=1
Xnand0 clkpll fz_tightloopb clkpll_b vccpll vssx ringpll__b15nand02al1n16x5 m=1
Xbfn02 reset_b rb vccpll vssx ringpll__b15bfn000al1n02x5 m=1
Xbfn01 tllm_force_tight_loop tftl vccpll vssx ringpll__b15bfn000al1n02x5 m=1
Xinv00 gate_gridclk gate_gridclkb vccpll vssx ringpll__b15inv000al1n08x5 m=1
Xinv01 fz_tightloop fz_tightloopb vccpll vssx ringpll__b15inv000al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_lfdef
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_lfdef rtrim_i[3] rtrim_i[2] rtrim_i[1] rtrim_i[0] rtrim[3] rtrim[2] rtrim[1] rtrim[0] vccpll vssx
* .PININFO rtrim[3]:I rtrim[2]:I rtrim[1]:I rtrim[0]:I vccpll:I vssx:I rtrim_i[3]:O rtrim_i[2]:O rtrim_i[1]:O rtrim_i[0]:O
Xand03 rtrim[3] alloneb rtrim_i[3] vccpll vssx ringpll__b15and002al1n03x5 m=1
Xand02 rtrim[2] alloneb rtrim_i[2] vccpll vssx ringpll__b15and002al1n03x5 m=1
Xand01 trim1int alloneb rtrim_i[1] vccpll vssx ringpll__b15and002al1n03x5 m=1
Xand00 rtrim[0] alloneb rtrim_i[0] vccpll vssx ringpll__b15and002al1n03x5 m=1
Xnand0 rtrim[3] rtrim[2] rtrim[1] rtrim[0] alloneb vccpll vssx ringpll__b15nand04al1n04x5 m=1
Xnor00 rtrim[3] rtrim[2] rtrim[1] rtrim[0] allzero vccpll vssx ringpll__b15nor004al1n02x5 m=1
Xorn00 allzero rtrim[1] trim1int vccpll vssx ringpll__b15orn002al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljpll_cpbuf
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljpll_cpbuf cp0d cp1d cp2d cp3d cp4d cp0 cp1 cp2 cp3 cp4 vccx vssx
* .PININFO cp0:I cp1:I cp2:I cp3:I cp4:I vccx:I vssx:I cp0d:O cp1d:O cp2d:O cp3d:O cp4d:O
Xdrv_cp2b cp2 cp2b vccx vssx ringpll__b15inv000al1n03x5 m=1
Xdrv_cp1b cp1 cp1b vccx vssx ringpll__b15inv000al1n03x5 m=1
Xdrv_cp3d cp3b cp3d vccx vssx ringpll__b15inv000al1n12x5 m=1
Xdrv_cp4d cp4b cp4d vccx vssx ringpll__b15inv000al1n12x5 m=1
Xdrv_cp1d cp1b cp1d vccx vssx ringpll__b15inv000al1n06x5 m=1
Xdrv_cp2d cp2b cp2d vccx vssx ringpll__b15inv000al1n06x5 m=1
Xinv04 cp4 cp4b vccx vssx ringpll__b15inv000al1n04x5 m=1
Xdrv_cp0d cp0b cp0d vccx vssx ringpll__b15inv000al1n04x5 m=1
Xnor01 cp4 n1 override vccx vssx ringpll__b15nor002al1n03x5 m=1
Xornc0 cp3 cp2 cp1 cp0 n1 vccx vssx ringpll__b15ornc04al1n03x5 m=1
Xdrv_cp0b cp0 cp0b vccx vssx ringpll__b15inv000al1n02x5 m=1
Xnor00 cp3 override cp3b vccx vssx ringpll__b15nor002al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pva
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pva clkpva clkvco en vccpll vssx
* .PININFO clkvco:I en:I vccpll:I vssx:I clkpva:O
Xmnres clkb eni clkcap vssx ringpll__nlp_s_pcell_104 m=1
Xmp0[1] clkb clkcap vccpll vccpll ringpll__plvt_s_pcell_122 m=1
Xmp0[0] clkb clkcap vccpll vccpll ringpll__plvt_s_pcell_122 m=1
Xmn0[1] clkb clkcap vssx vssx ringpll__nlvt_s_pcell_123 m=1
Xmn0[0] clkb clkcap vssx vssx ringpll__nlvt_s_pcell_123 m=1
Mmn9 clkpva clkpvab vssx vssx nlp W=90n L=40n M=2
Mmn8 clkpvab clkb vssx vssx nlp W=90n L=40n M=2
Mmp8 clkcap eni vccpll vccpll plp W=90n L=40n M=1
Mmp7 clkpva clkpvab vccpll vccpll plp W=90n L=40n M=2
Mmp6 clkpvab clkb vccpll vccpll plp W=90n L=40n M=2
Xmpres clkb enb clkcap vccpll ringpll__plp_s_pcell_124 m=1
Xinv01 enb eni vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xinv00 en enb vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xicap clkcap clkvco nc2 vssx ringpll__mfc_s2s_ls_pcell_125
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vcopullupunit_p_s6
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vcopullupunit_p_s6 vro dgenb[2] dgenb[1] dgenb[0] enb pgb vccpll vctl vssx
* .PININFO dgenb[2]:I dgenb[1]:I dgenb[0]:I enb:I pgb:I vccpll:I vctl:I vssx:I vro:B
Mmpdum2 vro vccpll vccpll vccpll p W=180n L=40n M=6
Mmpdum1 sw vccpll vccpll vccpll p W=180n L=40n M=6
Xior[2] pgb enb dgenb[2] pb[2] vccpll vssx ringpll__b15orn003al1n02x5 m=1
Xior[1] pgb enb dgenb[1] pb[1] vccpll vssx ringpll__b15orn003al1n02x5 m=1
Xior[0] pgb enb dgenb[0] pb[0] vccpll vssx ringpll__b15orn003al1n02x5 m=1
Xmp2 sw pb[2] vccpll vccpll ringpll__p_s_pcell_118 m=1
Xmp0[4] sw pb[0] vccpll vccpll ringpll__p_s_pcell_118 m=1
Xmp0[3] sw pb[0] vccpll vccpll ringpll__p_s_pcell_118 m=1
Xmp0[2] sw pb[0] vccpll vccpll ringpll__p_s_pcell_118 m=1
Xmp0[1] sw pb[0] vccpll vccpll ringpll__p_s_pcell_118 m=1
Xmp4[5] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp4[4] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp4[3] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp4[2] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp4[1] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp4[0] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp1[2] sw pb[1] vccpll vccpll ringpll__p_s_pcell_118 m=1
Xmp1[1] sw pb[1] vccpll vccpll ringpll__p_s_pcell_118 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vcopullupunit
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vcopullupunit vro dgenb[2] dgenb[1] dgenb[0] enb pgb vccpll vctl vssx
* .PININFO dgenb[2]:I dgenb[1]:I dgenb[0]:I enb:I pgb:I vccpll:I vctl:I vssx:I vro:B
Mmpdum2 vro vccpll vccpll vccpll p W=180n L=40n M=6
Mmpdum1 sw vccpll vccpll vccpll p W=180n L=40n M=6
Mmp2 sw pb[2] vccpll vccpll p W=90n L=40n M=1
Mmp0 sw pb[0] vccpll vccpll p W=180n L=40n M=2
Mmp1 sw pb[1] vccpll vccpll p W=180n L=40n M=1
Xior[2] pgb enb dgenb[2] pb[2] vccpll vssx ringpll__b15orn003al1n02x5 m=1
Xior[1] pgb enb dgenb[1] pb[1] vccpll vssx ringpll__b15orn003al1n02x5 m=1
Xior[0] pgb enb dgenb[0] pb[0] vccpll vssx ringpll__b15orn003al1n02x5 m=1
Xmp4[5] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp4[4] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp4[3] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp4[2] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp4[1] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
Xmp4[0] vro vctl sw vccpll ringpll__p_s_pcell_119 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vcopvadiv
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vcopvadiv clkout clkin pdivrat[1] pdivrat[0] vccpll vssx
* .PININFO clkin:I pdivrat[1]:I pdivrat[0]:I vccpll:I vssx:I clkout:O
Xmdn00 clkmuxb vccpll vssx s0 s1 s2 pdivratb[1] no10b no10 ringpll__pllx22_b15mdn003xn1n08x5
Xinv07 pdivratb[1] rb1 vccpll vssx ringpll__b15inv000al1n03x5 m=1
Xnand3 clkmuxsb vccpll vssx selin clkmux ringpll__pllx22_b15nand22xn1n08x5
Xnand2 clk1xb vccpll vssx selinb clkin ringpll__pllx22_b15nand22xn1n08x5
Xnand1 clkout vccpll vssx clk1xb clkmuxsb ringpll__pllx22_b15nand22xn1n08x5
Xinv02 n02 d1 vccpll vssx ringpll__b15inv000an1n04x5 m=1
Xinv04 n03 d2 vccpll vssx ringpll__b15inv000an1n04x5 m=1
Xinv00 n01 d0 vccpll vssx ringpll__b15inv000an1n04x5 m=1
Xnor00 pdivratb[0] pdivratb[1] rb2 vccpll vssx ringpll__b15nor002an1n03x5 m=1
Xinv03 s0 s0b vccpll vssx ringpll__b15inv000an1n02x5 m=1
Xinv06 pdivrat[1] pdivratb[1] vccpll vssx ringpll__b15inv000al1n02x5 m=1
Xinv05 pdivrat[0] pdivratb[0] vccpll vssx ringpll__b15inv000al1n02x5 m=1
Xfan01 s1 vccpll vssx s0 d1 rb1 ringpll__pllx22_b15fan003xn1n08x5
Xfan02 s2 vccpll vssx s1 d2 rb2 ringpll__pllx22_b15fan003xn1n08x5
Xfan00 s0 vccpll vssx clkin d0 selin ringpll__pllx22_b15fan003xn1n08x5
Xnor02 pdivratb[1] pdivratb[0] no10 vccpll vssx ringpll__b15nor002al1n03x5 m=1
Xnor01 pdivrat[0] pdivratb[1] no10b vccpll vssx ringpll__b15nor002al1n03x5 m=1
Xinv08 selin selinb vccpll vssx ringpll__b15inv000an1n03x5 m=1
Xinv01 s0b n01 vccpll vssx ringpll__b15inv000an1n03x5 m=1
Xbfm41 s2 n03 vccpll vssx ringpll__b15bfm402an1n04x5 m=1
Xbfm40 s1 n02 vccpll vssx ringpll__b15bfm402an1n04x5 m=1
Xnand0 pdivratb[0] pdivratb[1] selin vccpll vssx ringpll__b15nand02al1n12x5 m=1
Xnor03 clkmux vccpll vssx vssx clkmuxb ringpll__pllx22_b15nor042xn1n04x5
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22aljiref2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22aljiref2 iref iref_view en iref_str[4] iref_str[3] iref_str[2] iref_str[1] iref_str[0] vccpll vro vssx
* .PININFO en:I iref_str[4]:I iref_str[3]:I iref_str[2]:I iref_str[1]:I iref_str[0]:I vccpll:I vro:I vssx:I iref:O iref_view:O
Mmn3 iref enb vssx vssx nlp W=360n L=40n M=1
Mmn2 vro enb vssx vssx nlp W=360n L=40n M=2
Mmn6 n1 eni nt vssx nlp W=90n L=40n M=1
Xinv_en enb eni vccpll vssx ringpll__b15inv000al1n03x5 m=1
Mmn0[2] n0 vro nt vssx n W=360n L=40n M=1
Mmn0[1] n0a vro nt vssx n W=360n L=40n M=1
Mmn1[2] pbias vro n0 vssx n W=360n L=40n M=1
Mmn1[1] pbias vro n0a vssx n W=360n L=40n M=1
Xnor00 iref_str[3] iref_str[2] iref_str[1] iref_str[0] idef vccpll vssx ringpll__b15nor004al1n02x5 m=1
Xinv00 en enb vccpll vssx ringpll__b15inv000al1n02x5 m=1
Xnand_pdrv[3] eni iref_str[3] iref_str_b[3] vccpll vssx ringpll__b15nand02al1n03x5 m=1
Xnand_pdrv[2] eni iref_str[2] iref_str_b[2] vccpll vssx ringpll__b15nand02al1n03x5 m=1
Xnand_pdrv[1] eni iref_str[1] iref_str_b[1] vccpll vssx ringpll__b15nand02al1n03x5 m=1
Xnand_pdrv[0] eni iref_str[0] iref_str_b[0] vccpll vssx ringpll__b15nand02al1n03x5 m=1
Xoai00 eni iref_str[4] idef iref_str_b[4] vccpll vssx ringpll__b15oai012al1n03x5 m=1
Mmp0 pbias eni vccpll vccpll plp W=180n L=40n M=1
Xpdrv_out1_ao[4] iref enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_ao[3] iref enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_ao[2] iref enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_ao[1] iref enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_0 iref iref_str_b[0] pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[16] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[15] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[14] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[13] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[12] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[11] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[10] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[9] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[8] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[7] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[6] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[5] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[4] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[3] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[2] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xdummy_pdrv_pbias[1] iref_view vssx pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[16] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[15] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[14] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[13] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[12] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[11] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[10] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[9] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[8] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[7] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[6] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[5] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[4] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[3] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[2] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_4[1] iref iref_str_b[4] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_2[4] iref iref_str_b[2] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_2[3] iref iref_str_b[2] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_2[2] iref iref_str_b[2] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_2[1] iref iref_str_b[2] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_3[8] iref iref_str_b[3] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_3[7] iref iref_str_b[3] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_3[6] iref iref_str_b[3] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_3[5] iref iref_str_b[3] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_3[4] iref iref_str_b[3] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_3[3] iref iref_str_b[3] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_3[2] iref iref_str_b[3] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_3[1] iref iref_str_b[3] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[12] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[11] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[10] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[9] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[8] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[7] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[6] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[5] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[4] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[3] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[2] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_pbias[1] pbias enb pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_1[2] iref iref_str_b[1] pbias vccpll ringpll__pllx22ljiref_pdrv
Xpdrv_out1_1[1] iref iref_str_b[1] pbias vccpll ringpll__pllx22ljiref_pdrv
Xmn4 pbias pbias n1 vssx ringpll__nlp_s_pcell_104 m=1
Xi26 nt vssx vssx ringpll__res_tfr_pcell_105
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljpll_fbmux_v2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljpll_fbmux_v2 fb tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 trim[3] trim[2] trim[1] trim[0] vccg vssx
* .PININFO tap0:I tap1:I tap2:I tap3:I tap4:I tap5:I tap6:I tap7:I tap8:I tap9:I tap10:I tap11:I tap12:I tap13:I tap14:I tap15:I trim[3]:I trim[2]:I
* .PININFO trim[1]:I trim[0]:I vccg:I vssx:I fb:O
Xidec sel[15] sel[14] sel[13] sel[12] sel[11] sel[10] sel[9] sel[8] sel[7] sel[6] sel[5] sel[4] sel[3] sel[2] sel[1] sel[0] sel_b[15] sel_b[14] sel_b[13] sel_b[12] sel_b[11] sel_b[10] sel_b[9] sel_b[8] sel_b[7] sel_b[6] sel_b[5] sel_b[4] sel_b[3] sel_b[2] sel_b[1] sel_b[0] trim[3] trim[2] trim[1] trim[0] vccg vssx ringpll__pllx22heldo_enc4to16
Xipass9 tap9 fb vccg sel[9] sel_b[9] vssx ringpll__pllx22ljpll_tgate
Xipass13 tap13 fb vccg sel[13] sel_b[13] vssx ringpll__pllx22ljpll_tgate
Xipass12 tap12 fb vccg sel[12] sel_b[12] vssx ringpll__pllx22ljpll_tgate
Xipass15 tap15 fb vccg sel[15] sel_b[15] vssx ringpll__pllx22ljpll_tgate
Xipass14 tap14 fb vccg sel[14] sel_b[14] vssx ringpll__pllx22ljpll_tgate
Xipass8 tap8 fb vccg sel[8] sel_b[8] vssx ringpll__pllx22ljpll_tgate
Xipass11 tap11 fb vccg sel[11] sel_b[11] vssx ringpll__pllx22ljpll_tgate
Xipass10 tap10 fb vccg sel[10] sel_b[10] vssx ringpll__pllx22ljpll_tgate
Xipass5 tap5 fb vccg sel[5] sel_b[5] vssx ringpll__pllx22ljpll_tgate
Xipass4 tap4 fb vccg sel[4] sel_b[4] vssx ringpll__pllx22ljpll_tgate
Xipass7 tap7 fb vccg sel[7] sel_b[7] vssx ringpll__pllx22ljpll_tgate
Xipass6 tap6 fb vccg sel[6] sel_b[6] vssx ringpll__pllx22ljpll_tgate
Xipass0 tap0 fb vccg sel[0] sel_b[0] vssx ringpll__pllx22ljpll_tgate
Xipass3 tap3 fb vccg sel[3] sel_b[3] vssx ringpll__pllx22ljpll_tgate
Xipass2 tap2 fb vccg sel[2] sel_b[2] vssx ringpll__pllx22ljpll_tgate
Xipass1 tap1 fb vccg sel[1] sel_b[1] vssx ringpll__pllx22ljpll_tgate
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_sutrip
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_sutrip trippd enb hitrip lotrip tripen vccpll vctl0 vssx
* .PININFO enb:I hitrip:I lotrip:I tripen:I vccpll:I vctl0:I vssx:I trippd:O
Xorn00 hitripb lotripb n1 vccpll vssx ringpll__b15orn002al1n02x5 m=1
Xnand0 tripen vctlpd enbi vccpll vssx ringpll__b15nand02al1n04x5 m=1
Xinv02 n2 n3 vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xinv016 vtrip n2 vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xnor03 vctlpdb sr_rst vctlpdi vccpll vssx ringpll__b15nor002al1n04x5 m=1
Xnor02 enb vctlpdi vctlpdb vccpll vssx ringpll__b15nor002al1n04x5 m=1
Mmp3 net46 enbi vccpll vccpll p W=270n L=40n M=4
Mmp1 vtrip vctl0 net46 vccpll p W=270n L=40n M=4
Xmn6 vtrip vctl0 net43 vssx ringpll__nlp_s_pcell_101 m=1
Xmn5 vtrip vctl0 net44 vssx ringpll__nlp_s_pcell_101 m=1
Xmn2 vtrip vctl0 net45 vssx ringpll__nlp_s_pcell_101 m=1
Mmn1 vtrip enbi vssx vssx nlp W=90n L=40n M=1
Mmn7 net43 lotripb vssx vssx nlp W=135n L=40n M=1
Mmn4 net44 n1 vssx vssx nlp W=135n L=40n M=1
Mmn3 net45 tripen vssx vssx nlp W=135n L=40n M=1
Xbfn02 lotrip lotripb vccpll vssx ringpll__b15bfn000al1n02x5 m=1
Xinv03 vctlpdb vctlpd vccpll vssx ringpll__b15inv000al1n04x5 m=1
Xand03 tripen vctlpd trippd vccpll vssx ringpll__b15and002al1n04x5 m=1
Xbfn01 n3 sr_rst vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xinv017 hitrip hitripb vccpll vssx ringpll__b15inv000al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_cnlx74ljpllresidualdly
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_cnlx74ljpllresidualdly dlyclkoutb clkin residly[2] residly[1] residly[0] vccxx vssx
* .PININFO clkin:I residly[2]:I residly[1]:I residly[0]:I vccxx:I vssx:I dlyclkoutb:O
Xbfm21 stg2 stg3 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xbfm20 clkin stg2 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xbfm22 stg3 stg4 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xnor00 rd0b rd1b sd vccxx vssx ringpll__b15nor002al1n04x5 m=1
Xnor01 rd1b residly[0] sc vccxx vssx ringpll__b15nor002al1n04x5 m=1
Xnor10 rd0b residly[1] sb vccxx vssx ringpll__b15nor002al1n04x5 m=1
Xnor11 residly[1] residly[0] sa vccxx vssx ringpll__b15nor002al1n04x5 m=1
Xmdn00 dlyclkoutb vccxx vssx clkin stg2 stg3 stg4 sa sb sc sd ringpll__pllx22_b15mdn004xn1n08x5
Xinvt0 residly[1] rd1b vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinvt1 residly[0] rd0b vccxx vssx ringpll__b15inv000al1n03x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_tcount
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_tcount tupenable enb fbclk refclk tenb tup vccpll vssx
* .PININFO enb:I fbclk:I refclk:I tenb:I tup:I vccpll:I vssx:I tupenable:O
Xand01 n1 q0 n2 vccpll vssx ringpll__b15and002al1n02x5 m=1
Xand05 tupdisableb q1 n1 vccpll vssx ringpll__b15and002al1n02x5 m=1
Xnand2 tupdisableb q0 d0 vccpll vssx ringpll__b15nand02al1n02x5 m=1
Xdmfix_xor00 q0 n1 d1 vccpll vssx ringpll__b15xor002al1n02x3 m=1
Xdmfix_xor01 n2 q2 d2 vccpll vssx ringpll__b15xor002al1n02x3 m=1
Xfqy021 refclkb d0 q0 rb vccpll vccpll vccpll vssx ringpll__b15fqy003an1n02x5 m=1
Xfqy016 refclkb d1 q1 rb vccpll vccpll vccpll vssx ringpll__b15fqy003an1n02x5 m=1
Xfqy017 refclkb d2 q2 rb vccpll vccpll vccpll vssx ringpll__b15fqy003an1n02x5 m=1
Xnanb0 tenb tupdisableb tupenb vccpll vssx ringpll__b15nanb02al1n02x5 m=1
Xinv01 tupenb tupenable vccpll vssx ringpll__b15inv000al1n04x5 m=1
Xinv06 fbclk nc vccpll vssx ringpll__b15inv000al1n04x5 m=1
Xinv05 refclk refclkb vccpll vssx ringpll__b15inv000al1n04x5 m=1
Xnor00 enb tup tenb rb vccpll vssx ringpll__b15nor003al1n04x5 m=1
Xnand0 q0 q1 q2 tupdisableb vccpll vssx ringpll__b15nand03al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_swhv
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_swhv io1 io2 en0 en1 sel0 vcchv vssx
* .PININFO en0:I en1:I sel0:I vcchv:I vssx:I io1:B io2:B
Mmn4 io1 en_d n0 vssx ntg W=360n L=160n M=1
Mmn5 n0 en_d io2 vssx ntg W=360n L=160n M=1
Xinv02 en_b en_d vcchv vssx ringpll__b15inv000ag1n04x5 m=1
Xmdn01 en0 en1 en_b sel0 vcchv vssx ringpll__b15mdn022ag1n04x5 m=1
Mmp4 io1 en_b n1 n1 ptg W=360n L=160n M=1
Mmp5 n1 en_b io2 n1 ptg W=360n L=160n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_swfbkhv
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_swfbkhv io1 io2 en0 en1 hi sel0 vcchv vssx
* .PININFO en0:I en1:I hi:I sel0:I vcchv:I vssx:I io1:B io2:B
Mmp1 io1 en_b n1 vcchv ptg W=360n L=160n M=1
Mmp0 n1 hi_b io2 vcchv ptg W=360n L=160n M=1
Xinv01 hi hi_b vcchv vssx ringpll__b15inv000ag1n04x5 m=1
Xinv00 en_b en_d vcchv vssx ringpll__b15inv000ag1n04x5 m=1
Mmn0 n0 hi_b io2 vssx ntg W=360n L=160n M=1
Mmn1 vssx en_d n0 vssx ntg W=360n L=160n M=1
Xmdn00 en0 en1 en_b sel0 vcchv vssx ringpll__b15mdn022ag1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_lsin_clk
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_lsin_clk out0 out1 in0 vcc_in vcc_out vssx
* .PININFO in0:I vcc_in:I vcc_out:I vssx:I out0:O out1:O
Xbfn01 out0 out1 vcc_out vssx ringpll__b15bfn001ah1n24x5 m=1
Xcsb00 in0 out0 vcc_in vcc_out vssx ringpll__b15csb0ndal1d16x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_glitchlessmux
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_glitchlessmux muxclk bypass en pllclk rb refclk vccpll vssx
* .PININFO bypass:I en:I pllclk:I rb:I refclk:I vccpll:I vssx:I muxclk:O
Xcinv3 refclk refclkb vccpll vssx ringpll__b15cinv00ah1n04x5 m=1
Xcinv2 refclkb refclkbuf vccpll vssx ringpll__b15cinv00ah1n04x5 m=1
Xcinv0 pllclk pllclkb vccpll vssx ringpll__b15cinv00ah1n04x5 m=1
Xcinv1 pllclkb pllclkbuf vccpll vssx ringpll__b15cinv00ah1n04x5 m=1
Xinv03 bypassib bypassi vccpll vssx ringpll__b15inv000al1n03x5 m=1
Xinv02 enclk enclkb vccpll vssx ringpll__b15inv000al1n03x5 m=1
Xinv01 enref enrefb vccpll vssx ringpll__b15inv000al1n03x5 m=1
Xinv00 bypassi bypassb vccpll vssx ringpll__b15inv000al1n03x5 m=1
Xand02 en enref enref2 vccpll vssx ringpll__b15and002al1n04x5 m=1
Xand00 bypassi enclkb n3 vccpll vssx ringpll__b15and002al1n04x5 m=1
Xand01 enrefb bypassb n1 vccpll vssx ringpll__b15and002al1n04x5 m=1
Xfmy21 pllclkbuf n1 n2i rb vccpll vccpll vccpll vssx ringpll__b15fmy203al1n04x5 m=1
Xfmy20 refclkbuf n3 n4i rb vccpll vccpll vccpll vssx ringpll__b15fmy203al1n04x5 m=1
Xnand11 refclki vccpll vssx refclk enref2 ringpll__pll_clknand
Xnand0 pllclki vccpll vssx pllclk enclk ringpll__pll_clknand
Xnand12 muxclk vccpll vssx pllclki refclki ringpll__pll_clknand
Xbfn01 n2i n2 vccpll vssx ringpll__b15bfn000al1n02x5 m=1
Xbfn00 n4i n4 vccpll vssx ringpll__b15bfn000al1n02x5 m=1
Xlyn00 pllclkb n2 enclk rb vccpll vssx ringpll__b15lyn003al1n04x5 m=1
Xlyn01 refclkb n4 enref rb vccpll vssx ringpll__b15lyn003al1n04x5 m=1
Xnonb0 en bypass bypassib vccpll vssx ringpll__b15nonb02al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_lsout
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_lsout out0 force0 in0 vcc_in vcc_out vssx
* .PININFO force0:I in0:I vcc_in:I vcc_out:I vssx:I out0:O
Xbfn01 n1 out0 vcc_out vssx ringpll__b15bfn001al1n24x5 m=1
Xsg000 force0 in0 n1 vcc_in vcc_out vssx ringpll__b15sg00d0bl1d04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_lsin
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_lsin out0 in0 vcc_in vcc_out vssx
* .PININFO in0:I vcc_in:I vcc_out:I vssx:I out0:O
Xsg000 in0 n1 vcc_in vcc_out vssx ringpll__b15sg00ndal1d04x5 m=1
Xbfn01 n1 out0 vcc_out vssx ringpll__b15bfn001al1n24x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    cpafdivcore_pllclk
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__cpafdivcore_pllclk clkout cueh rstd clkinb rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 rst vccx vssx
* .PININFO clkinb:I rat0p5:I rat[9]:I rat[8]:I rat[7]:I rat[6]:I rat[5]:I rat[4]:I rat[3]:I rat[2]:I rat[1]:I rat[0]:I rst:I vccx:I vssx:I clkout:O
* .PININFO cueh:O rstd:O
Xinv01 rst rst_b vccx vssx ringpll__b15inv000al1n16x5 m=1
Xcoen6 s[0] s[1] s[2] z20 vccx vssx ringpll__b15nor003ah1n08x5 m=1
Xlatogeb clklb sb[9] togb vccx vssx ringpll__b15lsn080ah1n04x5 m=1
Xdmfix_xor05 s[1] s[2] cinb_2 vccx vssx ringpll__b15xor002ah1n04x5 m=1
Xdmfix_xor04 s[3] s[4] cinb_4 vccx vssx ringpll__b15xor002ah1n04x5 m=1
Xdmfix_xor03 rat[3] cin3 ratd[3] vccx vssx ringpll__b15xor002al1n08x5 m=1
Xdmfix_xor02 rat[5] cin5 ratd[5] vccx vssx ringpll__b15xor002al1n08x5 m=1
Xdmfix_xor01 rat[7] cin7 ratd[7] vccx vssx ringpll__b15xor002al1n08x5 m=1
Xdmfix_xor00 rat[9] cin9 ratd[9] vccx vssx ringpll__b15xor002al1n08x5 m=1
Xnand4 sb_8 z76 z54 zb84 vccx vssx ringpll__b15nand03ah1n03x5 m=1
Xdmfix_xnr08 z43 s[5] cinb_5 vccx vssx ringpll__b15xnr002ah1n03x5 m=1
Xdmfix_xnr07 z53 s[6] cinb_6 vccx vssx ringpll__b15xnr002ah1n03x5 m=1
Xdmfix_xnr06 z63 s[7] cinb_7 vccx vssx ringpll__b15xnr002ah1n03x5 m=1
Xdmfix_xnr05 z73 s[8] cinb[8] vccx vssx ringpll__b15xnr002ah1n03x5 m=1
Xmbn08 rat[1] ratb_1 ratm[1] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn07 rat[2] ratd[2] ratm[2] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn06 rat[3] ratd[3] ratm[3] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn05 rat[5] ratd[5] ratm[5] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn04 rat[4] ratd[4] ratm[4] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn03 rat[6] ratd[6] ratm[6] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn02 rat[7] ratd[7] ratm[7] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn01 rat[8] ratd[8] ratm[8] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn00 rat[9] ratd[9] ratm[9] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xinv018 s[0] sb_0 vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv013 ratm[1] ratmb[1] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv012 ratm[2] ratmb[2] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv011 ratm[3] ratmb[3] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv010 ratm[5] ratmb[5] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv09 ratm[4] ratmb[4] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv08 ratm[7] ratmb[7] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv06 ratm[6] ratmb[6] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv04 ratm[9] ratmb[9] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv05 ratm[8] ratmb[8] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinphhd sb[9] sd[9] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv03 clkinb clklb vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xnor016 rsts rstd rstr vccx vssx ringpll__b15nor002al1n03x5 m=1
Xnor015 s[9] rstr rsts vccx vssx ringpll__b15nor002al1n03x5 m=1
Xaoi07 s[0] reload ratmb[1] cin[0] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi06 s[1] reload ratmb[2] cin[1] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi05 cinb_2 reload ratmb[3] cin[2] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi04 s[3] reload ratmb[4] cin[3] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi03 cinb_4 reload ratmb[5] cin[4] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi02 cinb_5 reload ratmb[6] cin[5] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi01 cinb_6 reload ratmb[7] cin[6] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi00 cinb_7 reload ratmb[8] cin[7] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xcon0 cinb[8] reload ratmb[9] cin[8] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xnor00 s[9] rat0p5b rsts cueh vccx vssx ringpll__b15nor003ah1n04x5 m=1
Xnor01 sb[9] ratb_0 selm1b vccx vssx ringpll__b15nor002ah1n16x5 m=1
Xinv021 reloadb reload vccx vssx ringpll__b15inv000ah1n20x5 m=1
Xnand8[1] da[2] da[3] dbb[1] vccx vssx ringpll__b15nand02ah1n08x5 m=1
Xnand8[0] da[0] da[1] dbb[0] vccx vssx ringpll__b15nand02ah1n08x5 m=1
Xnand7 clkinb sb_0 clk21 vccx vssx ringpll__b15nand02ah1n08x5 m=1
Xnor010 s[5] s[4] z54 vccx vssx ringpll__b15nor002al1n08x5 m=1
Xnand6 sb_6 z54 zb64 vccx vssx ringpll__b15nand02ah1n04x5 m=1
Xnand5 z76 z54 zb74 vccx vssx ringpll__b15nand02ah1n04x5 m=1
Xinv019 rst_b rstd vccx vssx ringpll__b15inv000al1n04x5 m=1
Xnor07 s[7] s[6] z76 vccx vssx ringpll__b15nor002ah1n04x5 m=1
Xinv017 z54 zb54 vccx vssx ringpll__b15inv000ah1n03x5 m=1
Xnor013[3] s[2] s[1] da[3] vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor013[2] s[4] s[3] da[2] vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor013[1] s[6] s[5] da[1] vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor013[0] s[8] s[7] da[0] vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor012 s[3] s[4] z43 vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor011 s[3] zb54 z53 vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor09 s[3] zb64 z63 vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor08 s[3] zb74 z73 vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor06 s[3] zb84 z83 vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xdmfix_xnr04 z83 s[9] cin[9] vccx vssx ringpll__b15xor002ah1n03x5 m=1
Xfqn09 clklb cin[0] s[0] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn00 clk93 cin[9] s[9] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn08 clk21 cin[1] s[1] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn07 clk21 cin[2] s[2] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn06 clk93 cin[3] s[3] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn05 clk93 cin[4] s[4] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn04 clk93 cin[5] s[5] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn03 clk93 cin[6] s[6] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn02 clk93 cin[7] s[7] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn01 clk93 cin[8] s[8] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xnor014 dbb[0] dbb[1] reload1 vccx vssx ringpll__b15nor002ah1n08x5 m=1
Xcacob togl sd[9] clkoutb vccx vssx ringpll__b15nor002ah1n08x5 m=1
Xintl togbd ratb_0 togl vccx vssx ringpll__b15nor002ah1n08x5 m=1
Xinrat[4] rat[7] ratb_7 vccx vssx ringpll__b15inv000al1n06x5 m=1
Xinrat[3] rat[5] ratb_5 vccx vssx ringpll__b15inv000al1n06x5 m=1
Xinrat[2] rat[3] ratb_3 vccx vssx ringpll__b15inv000al1n06x5 m=1
Xinrat[1] rat[1] ratb_1 vccx vssx ringpll__b15inv000al1n06x5 m=1
Xinrat[0] rat[0] ratb_0 vccx vssx ringpll__b15inv000al1n06x5 m=1
Xnacout clkoutb clkout vccx vssx ringpll__b15inv000al1n06x5 m=1
Xbfm20 togb togbd vccx vssx ringpll__b15bfm201ah1n04x5 m=1
Xinv02 rat0p5 rat0p5b vccx vssx ringpll__b15inv000al1n02x5 m=1
Xinv016 s[6] sb_6 vccx vssx ringpll__b15inv000al1n02x5 m=1
Xinv014 s[8] sb_8 vccx vssx ringpll__b15inv000al1n02x5 m=1
Xinv07 s[9] sb[9] vccx vssx ringpll__b15inv000ah1n12x5 m=1
Xinv020 reload1 reloadb vccx vssx ringpll__b15inv000ah1n12x5 m=1
Xnand9 clkinb z20 clk93 vccx vssx ringpll__b15nandp2ah1n08x5 m=1
Xnand10 clkinb z20 clk93 vccx vssx ringpll__b15nandp2ah1n08x5 m=1
Xnor05 rat[2] rat[1] cin3 vccx vssx ringpll__b15nor002al1n06x5 m=1
Xnor04 rat[4] cinb4 cin5 vccx vssx ringpll__b15nor002al1n06x5 m=1
Xnor03 rat[6] cin6b cin7 vccx vssx ringpll__b15nor002al1n06x5 m=1
Xnor02 rat[8] cinb8 cin9 vccx vssx ringpll__b15nor002al1n06x5 m=1
Xdmfix_xnr03 rat[2] rat[1] ratd[2] vccx vssx ringpll__b15xnr002al1n08x5 m=1
Xdmfix_xnr02 rat[4] cinb4 ratd[4] vccx vssx ringpll__b15xnr002al1n08x5 m=1
Xdmfix_xnr01 rat[6] cin6b ratd[6] vccx vssx ringpll__b15xnr002al1n08x5 m=1
Xdmfix_xnr00 rat[8] cinb8 ratd[8] vccx vssx ringpll__b15xnr002al1n08x5 m=1
Xnand2 ratb_3 cin3 cinb4 vccx vssx ringpll__b15nand02al1n08x5 m=1
Xnand0 ratb_5 cin5 cin6b vccx vssx ringpll__b15nand02al1n08x5 m=1
Xnand1 ratb_7 cin7 cinb8 vccx vssx ringpll__b15nand02al1n08x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    cpafdivcore
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__cpafdivcore clkout cueh rstd clkinb rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 rst vccx vssx
* .PININFO clkinb:I rat0p5:I rat[9]:I rat[8]:I rat[7]:I rat[6]:I rat[5]:I rat[4]:I rat[3]:I rat[2]:I rat[1]:I rat[0]:I rst:I vccx:I vssx:I clkout:O
* .PININFO cueh:O rstd:O
Xcoen6 s[0] s[1] s[2] z20 vccx vssx ringpll__b15nor003ah1n08x5 m=1
Xlatogeb clklb sb[9] togb vccx vssx ringpll__b15lsn080ah1n04x5 m=1
Xdmfix_xor05 s[1] s[2] cinb_2 vccx vssx ringpll__b15xor002ah1n04x5 m=1
Xdmfix_xor04 s[3] s[4] cinb_4 vccx vssx ringpll__b15xor002ah1n04x5 m=1
Xdmfix_xor03 rat[3] cin3 ratd[3] vccx vssx ringpll__b15xor002al1n08x5 m=1
Xdmfix_xor02 rat[5] cin5 ratd[5] vccx vssx ringpll__b15xor002al1n08x5 m=1
Xdmfix_xor01 rat[7] cin7 ratd[7] vccx vssx ringpll__b15xor002al1n08x5 m=1
Xdmfix_xor00 rat[9] cin9 ratd[9] vccx vssx ringpll__b15xor002al1n08x5 m=1
Xnand4 sb_8 z76 z54 zb84 vccx vssx ringpll__b15nand03ah1n03x5 m=1
Xdmfix_xnr08 z43 s[5] cinb_5 vccx vssx ringpll__b15xnr002ah1n03x5 m=1
Xdmfix_xnr07 z53 s[6] cinb_6 vccx vssx ringpll__b15xnr002ah1n03x5 m=1
Xdmfix_xnr06 z63 s[7] cinb_7 vccx vssx ringpll__b15xnr002ah1n03x5 m=1
Xdmfix_xnr05 z73 s[8] cinb[8] vccx vssx ringpll__b15xnr002ah1n03x5 m=1
Xmbn08 rat[1] ratb_1 ratm[1] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn07 rat[2] ratd[2] ratm[2] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn06 rat[3] ratd[3] ratm[3] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn05 rat[5] ratd[5] ratm[5] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn04 rat[4] ratd[4] ratm[4] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn03 rat[6] ratd[6] ratm[6] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn02 rat[7] ratd[7] ratm[7] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn01 rat[8] ratd[8] ratm[8] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xmbn00 rat[9] ratd[9] ratm[9] selm1b vccx vssx ringpll__b15mbn022ah1n08x5 m=1
Xinv018 s[0] sb_0 vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv013 ratm[1] ratmb[1] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv012 ratm[2] ratmb[2] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv011 ratm[3] ratmb[3] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv010 ratm[5] ratmb[5] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv09 ratm[4] ratmb[4] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv08 ratm[7] ratmb[7] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv06 ratm[6] ratmb[6] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv04 ratm[9] ratmb[9] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv05 ratm[8] ratmb[8] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinphhd sb[9] sd[9] vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xinv03 clkinb clklb vccx vssx ringpll__b15inv000ah1n06x5 m=1
Xnor016 rsts rstd rstr vccx vssx ringpll__b15nor002al1n03x5 m=1
Xnor015 s[9] rstr rsts vccx vssx ringpll__b15nor002al1n03x5 m=1
Xaoi07 s[0] reload ratmb[1] cin[0] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi06 s[1] reload ratmb[2] cin[1] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi05 cinb_2 reload ratmb[3] cin[2] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi04 s[3] reload ratmb[4] cin[3] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi03 cinb_4 reload ratmb[5] cin[4] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi02 cinb_5 reload ratmb[6] cin[5] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi01 cinb_6 reload ratmb[7] cin[6] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xaoi00 cinb_7 reload ratmb[8] cin[7] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xcon0 cinb[8] reload ratmb[9] cin[8] vccx vssx ringpll__b15aoi012ah1n04x5 m=1
Xnor00 s[9] rat0p5b rsts cueh vccx vssx ringpll__b15nor003ah1n04x5 m=1
Xnor01 sb[9] ratb_0 selm1b vccx vssx ringpll__b15nor002ah1n16x5 m=1
Xinv021 reloadb reload vccx vssx ringpll__b15inv000ah1n20x5 m=1
Xnand8[1] da[2] da[3] dbb[1] vccx vssx ringpll__b15nand02ah1n08x5 m=1
Xnand8[0] da[0] da[1] dbb[0] vccx vssx ringpll__b15nand02ah1n08x5 m=1
Xnand7 clkinb sb_0 clk21 vccx vssx ringpll__b15nand02ah1n08x5 m=1
Xnor010 s[5] s[4] z54 vccx vssx ringpll__b15nor002al1n08x5 m=1
Xnand6 sb_6 z54 zb64 vccx vssx ringpll__b15nand02ah1n04x5 m=1
Xnand5 z76 z54 zb74 vccx vssx ringpll__b15nand02ah1n04x5 m=1
Xinv019 rst_b rstd vccx vssx ringpll__b15inv000al1n04x5 m=1
Xnor07 s[7] s[6] z76 vccx vssx ringpll__b15nor002ah1n04x5 m=1
Xinv017 z54 zb54 vccx vssx ringpll__b15inv000ah1n03x5 m=1
Xnor013[3] s[2] s[1] da[3] vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor013[2] s[4] s[3] da[2] vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor013[1] s[6] s[5] da[1] vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor013[0] s[8] s[7] da[0] vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor012 s[3] s[4] z43 vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor011 s[3] zb54 z53 vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor09 s[3] zb64 z63 vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor08 s[3] zb74 z73 vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xnor06 s[3] zb84 z83 vccx vssx ringpll__b15nor002ah1n03x5 m=1
Xdmfix_xnr04 z83 s[9] cin[9] vccx vssx ringpll__b15xor002ah1n03x5 m=1
Xfqn09 clklb cin[0] s[0] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn00 clk93 cin[9] s[9] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn08 clk21 cin[1] s[1] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn07 clk21 cin[2] s[2] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn06 clk93 cin[3] s[3] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn05 clk93 cin[4] s[4] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn04 clk93 cin[5] s[5] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn03 clk93 cin[6] s[6] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn02 clk93 cin[7] s[7] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xfqn01 clk93 cin[8] s[8] rst_b vccx vssx ringpll__b15fqn003ah1n08x5 m=1
Xnor014 dbb[0] dbb[1] reload1 vccx vssx ringpll__b15nor002ah1n08x5 m=1
Xcacob togl sd[9] clkoutb vccx vssx ringpll__b15nor002ah1n08x5 m=1
Xintl togbd ratb_0 togl vccx vssx ringpll__b15nor002ah1n08x5 m=1
Xinrat[4] rat[7] ratb_7 vccx vssx ringpll__b15inv000al1n06x5 m=1
Xinrat[3] rat[5] ratb_5 vccx vssx ringpll__b15inv000al1n06x5 m=1
Xinrat[2] rat[3] ratb_3 vccx vssx ringpll__b15inv000al1n06x5 m=1
Xinrat[1] rat[1] ratb_1 vccx vssx ringpll__b15inv000al1n06x5 m=1
Xinrat[0] rat[0] ratb_0 vccx vssx ringpll__b15inv000al1n06x5 m=1
Xnacout clkoutb clkout vccx vssx ringpll__b15inv000al1n06x5 m=1
Xinv01 rst rst_b vccx vssx ringpll__b15inv000al1n06x5 m=1
Xbfm20 togb togbd vccx vssx ringpll__b15bfm201ah1n04x5 m=1
Xinv02 rat0p5 rat0p5b vccx vssx ringpll__b15inv000al1n02x5 m=1
Xinv016 s[6] sb_6 vccx vssx ringpll__b15inv000al1n02x5 m=1
Xinv014 s[8] sb_8 vccx vssx ringpll__b15inv000al1n02x5 m=1
Xinv07 s[9] sb[9] vccx vssx ringpll__b15inv000ah1n12x5 m=1
Xinv020 reload1 reloadb vccx vssx ringpll__b15inv000ah1n12x5 m=1
Xnand9 clkinb z20 clk93 vccx vssx ringpll__b15nandp2ah1n08x5 m=1
Xnand10 clkinb z20 clk93 vccx vssx ringpll__b15nandp2ah1n08x5 m=1
Xnor05 rat[2] rat[1] cin3 vccx vssx ringpll__b15nor002al1n06x5 m=1
Xnor04 rat[4] cinb4 cin5 vccx vssx ringpll__b15nor002al1n06x5 m=1
Xnor03 rat[6] cin6b cin7 vccx vssx ringpll__b15nor002al1n06x5 m=1
Xnor02 rat[8] cinb8 cin9 vccx vssx ringpll__b15nor002al1n06x5 m=1
Xdmfix_xnr03 rat[2] rat[1] ratd[2] vccx vssx ringpll__b15xnr002al1n08x5 m=1
Xdmfix_xnr02 rat[4] cinb4 ratd[4] vccx vssx ringpll__b15xnr002al1n08x5 m=1
Xdmfix_xnr01 rat[6] cin6b ratd[6] vccx vssx ringpll__b15xnr002al1n08x5 m=1
Xdmfix_xnr00 rat[8] cinb8 ratd[8] vccx vssx ringpll__b15xnr002al1n08x5 m=1
Xnand2 ratb_3 cin3 cinb4 vccx vssx ringpll__b15nand02al1n08x5 m=1
Xnand0 ratb_5 cin5 cin6b vccx vssx ringpll__b15nand02al1n08x5 m=1
Xnand1 ratb_7 cin7 cinb8 vccx vssx ringpll__b15nand02al1n08x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_cnlx74ljpllpgatepfdctrl
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_cnlx74ljpllpgatepfdctrl pgdly0 pgdly1 reforfbk disablepfdpwrgate fbkclkin pgatedlytrim[1] pgatedlytrim[0] refclkin vccxx vssx
* .PININFO disablepfdpwrgate:I fbkclkin:I pgatedlytrim[1]:I pgatedlytrim[0]:I refclkin:I vccxx:I vssx:I pgdly0:O pgdly1:O reforfbk:O
Xnanb0 disablepfdpwrgate pgdt[0] pgdly0_b vccxx vssx ringpll__b15nanb02al1n02x5 m=1
Xnanb1 disablepfdpwrgate pgdt[1] pgdly1_b vccxx vssx ringpll__b15nanb02al1n02x5 m=1
Xino0 refclkin fbkclkin reforfbk_b vccxx vssx ringpll__b15nor002al1n03x5 m=1
Xtinv2[1] pgdt_b[1] pgdt[1] vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xtinv2[0] pgdt_b[0] pgdt[0] vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xtinv1[1] pgatedlytrim[1] pgdt_b[1] vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xtinv1[0] pgatedlytrim[0] pgdt_b[0] vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinv00 pgdly0_b pgdly0 vccxx vssx ringpll__b15inv000al1n04x5 m=1
Xinv03 pgdly1_b pgdly1 vccxx vssx ringpll__b15inv000al1n04x5 m=1
Xiiad reforfbk_b reforfbk vccxx vssx ringpll__b15inv000al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_novclkgenprim
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_novclkgenprim ckph1 ckph2 ckin ckph1fb_b ckph2fb_b vccxx vssx
* .PININFO ckin:I ckph1fb_b:I ckph2fb_b:I vccxx:I vssx:I ckph1:O ckph2:O
Xand01 n0 n3 ckph2 vccxx vssx ringpll__b15and002al1n08x5 m=1
Xand00 ckin n1 ckph1 vccxx vssx ringpll__b15and002al1n08x5 m=1
Xi63 ckph1fb_b net9 vccxx vssx ringpll__b15bfm201al1n02x5 m=1
Xi61 n8 n1 vccxx vssx ringpll__b15bfm201al1n02x5 m=1
Xi62 net9 n0 vccxx vssx ringpll__b15bfm201al1n02x5 m=1
Xi60 ckph2fb_b n8 vccxx vssx ringpll__b15bfm201al1n02x5 m=1
Xi26 ckin n3 vccxx vssx ringpll__b15inv000al1n03x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_doutff
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_doutff sdfdbk sdmodout chop ckph1 sdmodout_ang vccxx vssx
* .PININFO chop:I ckph1:I sdmodout_ang:I vccxx:I vssx:I sdfdbk:O sdmodout:O
Xmbn0 net21 sdmodout_ang net15 chop vccxx vssx ringpll__b15mbn022al1n04x5 m=1
Xfsn0 ckph1 net16 net18 vccxx vssx ringpll__b15fpn000al1n04x5 m=1
Xi1 net15 net22 vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xi2 net22 net16 vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xi11 sdmodout_ang net21 vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xi4 net18 n5 vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xi5 n5 sdmodout vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xi6 n5 sdfdbk vccxx vssx ringpll__b15inv000al1n06x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_lsout_clk2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_lsout_clk2 out0b force0b in0 vcc_in vcc_out vssx
* .PININFO force0b:I in0:I vcc_in:I vcc_out:I vssx:I out0b:O
Xcinv2 clki out0b vcc_out vssx ringpll__b15cinv00ah1n12x5 m=1
Xcsb01 clki clkb force0b vcc_in vcc_out vssx ringpll__pll_clk_ls
Xcinv0 in0 clkb vcc_in vssx ringpll__b15cinv00ah1n08x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_pllcoldcatop
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_pllcoldcatop clkout cb[1] cb[0] clkin ctrl[5] ctrl[4] ctrl[3] ctrl[2] ctrl[1] ctrl[0] vccxx vssx
* .PININFO cb[1]:I cb[0]:I clkin:I ctrl[5]:I ctrl[4]:I ctrl[3]:I ctrl[2]:I ctrl[1]:I ctrl[0]:I vccxx:I vssx:I clkout:O
Xicol2 clk2b tieup2 cb[1] cb[0] tieup2 vssx clk1 hob[5] hob[4] hob[3] hob[2] hob[1] hob[4] hob[3] hob[2] hob[1] hob[0] lob[4] lob[4] lob[4] lob[4] lob[4] hob[1] hob[2] hob[3] hob[4] hob[5] hob[2] hob[3] hob[4] hob[5] hob[6] lob[1] lob[1] lob[1] lob[1] lob[1] vccxx vssx ringpll__pll_pllcolestun18
Xicol3 clk3 tieup3 cb[1] cb[0] tieup3 vssx clk2b ho[1] ho[2] ho[3] ho[4] ho[5] tieup3 tieup3 tieup3 tieup3 tieup3 tieup3 tieup3 tieup3 tieup3 tieup3 ho[6] ho[5] ho[4] ho[3] ho[2] ho[5] ho[4] ho[3] ho[2] ho[1] lo_2 lo_2 lo_2 lo_2 lo_2 vccxx vssx ringpll__pll_pllcolestun18
Xicol1 clk1 tieup1 cb[1] cb[0] tieup1 vssx clk0b ho[1] ho[2] ho[3] ho[4] ho[5] ho[2] ho[3] ho[4] ho[5] ho[6] lo_3 lo_3 lo_3 lo_3 lo_3 ho[5] ho[4] ho[3] ho[2] ho[1] ho[4] ho[3] ho[2] ho[1] ho[0] lo_6 lo_6 lo_6 lo_6 lo_6 vccxx vssx ringpll__pll_pllcolestun18
Xicol0 clk0b tieup0 cb[1] cb[0] tieup0 vssx clkin hob[6] hob[5] hob[4] hob[3] hob[2] hob[5] hob[4] hob[3] hob[2] hob[1] lob[0] lob[0] lob[0] lob[0] lob[0] hob[0] hob[1] hob[2] hob[3] hob[4] hob[1] hob[2] hob[3] hob[4] hob[5] lob[5] lob[5] lob[5] lob[5] lob[5] vccxx vssx ringpll__pll_pllcolestun18
Xinv03[6] lox[6] lob[6] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv03[5] lox[5] lob[5] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv03[4] lox[4] lob[4] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv03[3] lox[3] lob[3] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv03[2] lox[2] lob[2] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv03[1] lox[1] lob[1] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv03[0] lox[0] lob[0] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv00[6] hox[6] hob[6] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv00[5] hox[5] hob[5] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv00[4] hox[4] hob[4] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv00[3] hox[3] hob[3] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv00[2] hox[2] hob[2] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv00[1] hox[1] hob[1] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xinv00[0] hox[0] hob[0] vccxx vssx ringpll__b15inv000an1n20x5 m=1
Xithlo lox[6] lox[5] lox[4] lox[3] lox[2] lox[1] lox[0] ctrl[2] ctrl[1] ctrl[0] vccxx vssx ringpll__pll_pllcolthenc
Xithho hox[6] hox[5] hox[4] hox[3] hox[2] hox[1] hox[0] ctrl[5] ctrl[4] ctrl[3] vccxx vssx ringpll__pll_pllcolthenc
Xinv02[2] lob[6] lo_6 vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv02[1] lob[3] lo_3 vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv02[0] lob[2] lo_2 vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv05 clk3b clkout vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv01[6] hob[6] ho[6] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv01[5] hob[5] ho[5] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv01[4] hob[4] ho[4] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv01[3] hob[3] ho[3] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv01[2] hob[2] ho[2] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv01[1] hob[1] ho[1] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv01[0] hob[0] ho[0] vccxx vssx ringpll__b15inv000an1n12x5 m=1
Xinv04 clk3 clk3b vccxx vssx ringpll__b15inv000an1n12x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_idvgate
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_idvgate clkidvih clkfbmxh idv_gate_en vccpll vssx
* .PININFO clkfbmxh:I idv_gate_en:I vccpll:I vssx:I clkidvih:O
Xinv00 n2 net6 vccpll vssx ringpll__b15inv000al1n02x5 m=1
Xbfn00 n2 clkidvih vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xclb00 clkfbmxh n0 idv_gate_en vccpll vssx ringpll__b15clb0a2al1n04x5 m=1
Xfqy00 n0 net6 n2 idv_gate_en vssx vccpll vccpll vssx ringpll__b15fqy003al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_3to8dec
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_3to8dec dec[7] dec[6] dec[5] dec[4] dec[3] dec[2] dec[1] dec[0] sel[2] sel[1] sel[0] vccxx vssx
* .PININFO sel[2]:I sel[1]:I sel[0]:I vccxx:I vssx:I dec[7]:O dec[6]:O dec[5]:O dec[4]:O dec[3]:O dec[2]:O dec[1]:O dec[0]:O
Xand00[7] s[2] s[1] s[0] dec[7] vccxx vssx ringpll__b15and003al1n02x5 m=1
Xand00[6] s[2] s[1] sb[0] dec[6] vccxx vssx ringpll__b15and003al1n02x5 m=1
Xand00[5] s[2] sb[1] s[0] dec[5] vccxx vssx ringpll__b15and003al1n02x5 m=1
Xand00[4] s[2] sb[1] sb[0] dec[4] vccxx vssx ringpll__b15and003al1n02x5 m=1
Xand00[3] sb[2] s[1] s[0] dec[3] vccxx vssx ringpll__b15and003al1n02x5 m=1
Xand00[2] sb[2] s[1] sb[0] dec[2] vccxx vssx ringpll__b15and003al1n02x5 m=1
Xand00[1] sb[2] sb[1] s[0] dec[1] vccxx vssx ringpll__b15and003al1n02x5 m=1
Xand00[0] sb[2] sb[1] sb[0] dec[0] vccxx vssx ringpll__b15and003al1n02x5 m=1
Xinv00[2] sel[2] sb[2] vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv00[1] sel[1] sb[1] vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv00[0] sel[0] sb[0] vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv01[2] sb[2] s[2] vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv01[1] sb[1] s[1] vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv01[0] sb[0] s[0] vccxx vssx ringpll__b15inv000al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_clkdivprim
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_clkdivprim ckdivby2 ck1x rst_b vccxx vssx
* .PININFO ck1x:I rst_b:I vccxx:I vssx:I ckdivby2:O
Xfan0 ck1x n4 ckdivby2 rst_b vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xinv00 ckdivby2 n4 vccxx vssx ringpll__b15inv000al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_dftdiv
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_dftdiv clkdiv2o clkdiv4o clk rb vccpll vssx
* .PININFO clk:I rb:I vccpll:I vssx:I clkdiv2o:O clkdiv4o:O
Xcbf01 clkdiv4 clkdiv4o vccpll vssx ringpll__b15cbf000al1n06x5 m=1
Xcbf00 clkdiv2 clkdiv2o vccpll vssx ringpll__b15cbf000al1n06x5 m=1
Xinv01 clkd4b clkdiv4 vccpll vssx ringpll__b15inv000al1n04x5 m=1
Xinv00 clkd2b clkdiv2 vccpll vssx ringpll__b15inv000al1n04x5 m=1
Xbfn00 rb rstb vccpll vssx ringpll__b15bfn000al1n02x5 m=1
Xcbf02 clk clkbuf vccpll vssx ringpll__b15cbf000al1n04x5 m=1
Xfqy01 clkdiv2 clkdiv4 clkd4b rstb vccpll vccpll vccpll vssx ringpll__b15fqy003al1n04x5 m=1
Xfqy00 clkbuf clkdiv2 clkd2b rstb vccpll vccpll vccpll vssx ringpll__b15fqy003al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_fbmux
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_fbmux fb tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 trim[3] trim[2] trim[1] trim[0] vccpll vssx
* .PININFO tap0:I tap1:I tap2:I tap3:I tap4:I tap5:I tap6:I tap7:I tap8:I tap9:I tap10:I tap11:I tap12:I tap13:I tap14:I tap15:I trim[3]:I trim[2]:I
* .PININFO trim[1]:I trim[0]:I vccpll:I vssx:I fb:O
Xidec sel[15] sel[14] sel[13] sel[12] sel[11] sel[10] sel[9] sel[8] sel[7] sel[6] sel[5] sel[4] sel[3] sel[2] sel[1] sel[0] sel_b[15] sel_b[14] sel_b[13] sel_b[12] sel_b[11] sel_b[10] sel_b[9] sel_b[8] sel_b[7] sel_b[6] sel_b[5] sel_b[4] sel_b[3] sel_b[2] sel_b[1] sel_b[0] trim[3] trim[2] trim[1] trim[0] vccpll vssx ringpll__x22heldo_enc4to16
Xipass9 tap9 fb sel[9] sel_b[9] vccpll vssx ringpll__x22heldo_tgate
Xipass13 tap13 fb sel[13] sel_b[13] vccpll vssx ringpll__x22heldo_tgate
Xipass12 tap12 fb sel[12] sel_b[12] vccpll vssx ringpll__x22heldo_tgate
Xipass15 tap15 fb sel[15] sel_b[15] vccpll vssx ringpll__x22heldo_tgate
Xipass14 tap14 fb sel[14] sel_b[14] vccpll vssx ringpll__x22heldo_tgate
Xipass8 tap8 fb sel[8] sel_b[8] vccpll vssx ringpll__x22heldo_tgate
Xipass11 tap11 fb sel[11] sel_b[11] vccpll vssx ringpll__x22heldo_tgate
Xipass10 tap10 fb sel[10] sel_b[10] vccpll vssx ringpll__x22heldo_tgate
Xipass5 tap5 fb sel[5] sel_b[5] vccpll vssx ringpll__x22heldo_tgate
Xipass4 tap4 fb sel[4] sel_b[4] vccpll vssx ringpll__x22heldo_tgate
Xipass7 tap7 fb sel[7] sel_b[7] vccpll vssx ringpll__x22heldo_tgate
Xipass6 tap6 fb sel[6] sel_b[6] vccpll vssx ringpll__x22heldo_tgate
Xipass0 tap0 fb sel[0] sel_b[0] vccpll vssx ringpll__x22heldo_tgate
Xipass3 tap3 fb sel[3] sel_b[3] vccpll vssx ringpll__x22heldo_tgate
Xipass2 tap2 fb sel[2] sel_b[2] vccpll vssx ringpll__x22heldo_tgate
Xipass1 tap1 fb sel[1] sel_b[1] vccpll vssx ringpll__x22heldo_tgate
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_fbmux_ref
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_fbmux_ref fb tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 trim[3] trim[2] trim[1] trim[0] vccpll vddh vssx
* .PININFO tap0:I tap1:I tap2:I tap3:I tap4:I tap5:I tap6:I tap7:I tap8:I tap9:I tap10:I tap11:I tap12:I tap13:I tap14:I tap15:I trim[3]:I trim[2]:I
* .PININFO trim[1]:I trim[0]:I vccpll:I vddh:I vssx:I fb:O
Xidec sel[15] sel[14] sel[13] sel[12] sel[11] sel[10] sel[9] sel[8] sel[7] sel[6] sel[5] sel[4] sel[3] sel[2] sel[1] sel[0] sel_b[15] sel_b[14] sel_b[13] sel_b[12] sel_b[11] sel_b[10] sel_b[9] sel_b[8] sel_b[7] sel_b[6] sel_b[5] sel_b[4] sel_b[3] sel_b[2] sel_b[1] sel_b[0] trim[3] trim[2] trim[1] trim[0] vccpll vssx ringpll__x22heldo_enc4to16
Xipass9 tap9 fb sel[9] sel_b[9] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass13 tap13 fb sel[13] sel_b[13] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass12 tap12 fb sel[12] sel_b[12] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass15 tap15 fb sel[15] sel_b[15] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass14 tap14 fb sel[14] sel_b[14] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass8 tap8 fb sel[8] sel_b[8] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass11 tap11 fb sel[11] sel_b[11] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass10 tap10 fb sel[10] sel_b[10] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass5 tap5 fb sel[5] sel_b[5] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass4 tap4 fb sel[4] sel_b[4] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass7 tap7 fb sel[7] sel_b[7] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass6 tap6 fb sel[6] sel_b[6] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass0 tap0 fb sel[0] sel_b[0] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass3 tap3 fb sel[3] sel_b[3] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass2 tap2 fb sel[2] sel_b[2] vccpll vddh vssx ringpll__x22heldo_tgate_ref
Xipass1 tap1 fb sel[1] sel_b[1] vccpll vddh vssx ringpll__x22heldo_tgate_ref
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    sigma_delta_23_1
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__sigma_delta_23_1 clkmodmxh lockxxnnnl reg_req_ack__mashstateresetmxh fractionmxh[22] fractionmxh[21] fractionmxh[20] fractionmxh[19] fractionmxh[18] fractionmxh[17] fractionmxh[16] fractionmxh[15] fractionmxh[14] fractionmxh[13] fractionmxh[12] fractionmxh[11] fractionmxh[10] fractionmxh[9] fractionmxh[8] fractionmxh[7] fractionmxh[6] fractionmxh[5] fractionmxh[4] fractionmxh[3] fractionmxh[2] fractionmxh[1] fractionmxh[0] errvalmxh[22] errvalmxh[21] errvalmxh[20] errvalmxh[19] errvalmxh[18] errvalmxh[17] errvalmxh[16] errvalmxh[15] errvalmxh[14] errvalmxh[13] errvalmxh[12] errvalmxh[11] errvalmxh[10] errvalmxh[9] errvalmxh[8] errvalmxh[7] errvalmxh[6] errvalmxh[5] errvalmxh[4] errvalmxh[3] errvalmxh[2] errvalmxh[1] errvalmxh[0] carrymxh vdd vssx p_abuf0 p_abuf1 p_abuf2 p_abuf3 p_abuf4 p_abuf5 p_abuf6
* .PININFO clkmodmxh:I fractionmxh[22]:I fractionmxh[21]:I fractionmxh[20]:I fractionmxh[19]:I fractionmxh[18]:I fractionmxh[17]:I fractionmxh[16]:I
* .PININFO fractionmxh[15]:I fractionmxh[14]:I fractionmxh[13]:I fractionmxh[12]:I fractionmxh[11]:I fractionmxh[10]:I fractionmxh[9]:I
* .PININFO fractionmxh[8]:I fractionmxh[7]:I fractionmxh[6]:I fractionmxh[5]:I fractionmxh[4]:I fractionmxh[3]:I fractionmxh[2]:I fractionmxh[1]:I
* .PININFO fractionmxh[0]:I lockxxnnnl:I p_abuf0:I p_abuf1:I p_abuf2:I p_abuf3:I p_abuf4:I p_abuf5:I p_abuf6:I reg_req_ack__mashstateresetmxh:I vdd:I
* .PININFO vssx:I carrymxh:O errvalmxh[22]:O errvalmxh[21]:O errvalmxh[20]:O errvalmxh[19]:O errvalmxh[18]:O errvalmxh[17]:O errvalmxh[16]:O
* .PININFO errvalmxh[15]:O errvalmxh[14]:O errvalmxh[13]:O errvalmxh[12]:O errvalmxh[11]:O errvalmxh[10]:O errvalmxh[9]:O errvalmxh[8]:O
* .PININFO errvalmxh[7]:O errvalmxh[6]:O errvalmxh[5]:O errvalmxh[4]:O errvalmxh[3]:O errvalmxh[2]:O errvalmxh[1]:O errvalmxh[0]:O
Xu557 errvalmxh[1] net145 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu560 errvalmxh[2] net148 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu561 errvalmxh[3] net149 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu559 errvalmxh[15] net147 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu558 errvalmxh[4] net146 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu555 errvalmxh[0] net143 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu552 errvalmxh[14] net140 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu551 errvalmxh[7] net139 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu550 errvalmxh[6] net138 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu547 errvalmxh[5] net135 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu461 errvalmxh[13] net52 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu533 errvalmxh[18] net121 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu531 errvalmxh[17] net119 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu530 errvalmxh[21] net118 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu525 errvalmxh[19] net113 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu524 errvalmxh[20] net112 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu523 errvalmxh[22] net111 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu492 errvalmxh[16] net80 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu478 errvalmxh[12] net66 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu477 errvalmxh[11] net65 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu475 errvalmxh[10] net63 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu466 errvalmxh[9] net57 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu465 errvalmxh[8] net56 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xcarryerrvalmxh_reg[4] clkmodmxh net146 carryerrvalmxh[4] p_abuf6 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[1] clkmodmxh net145 carryerrvalmxh[1] p_abuf1 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[2] clkmodmxh net148 carryerrvalmxh[2] p_abuf1 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[3] clkmodmxh net149 carryerrvalmxh[3] p_abuf6 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[14] clkmodmxh net140 carryerrvalmxh[14] p_abuf6 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[15] clkmodmxh net147 carryerrvalmxh[15] p_abuf6 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[6] clkmodmxh net138 carryerrvalmxh[6] p_abuf6 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[9] clkmodmxh net57 carryerrvalmxh[9] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[13] clkmodmxh net52 carryerrvalmxh[13] p_abuf6 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[11] clkmodmxh net65 carryerrvalmxh[11] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[8] clkmodmxh net56 carryerrvalmxh[8] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[16] clkmodmxh net80 carryerrvalmxh[16] p_abuf0 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[10] clkmodmxh net63 carryerrvalmxh[10] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[12] clkmodmxh net66 carryerrvalmxh[12] lockxxnnnl vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[22] clkmodmxh net111 carryerrvalmxh[22] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[18] clkmodmxh net121 carryerrvalmxh[18] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[20] clkmodmxh net112 carryerrvalmxh[20] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[5] clkmodmxh net135 carryerrvalmxh[5] p_abuf6 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[19] clkmodmxh net113 carryerrvalmxh[19] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[7] clkmodmxh net139 carryerrvalmxh[7] p_abuf6 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[21] clkmodmxh net118 carryerrvalmxh[21] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[0] clkmodmxh net143 carryerrvalmxh[0] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xcarryerrvalmxh_reg[17] clkmodmxh net119 carryerrvalmxh[17] p_abuf2 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xu6 fractionmxh[0] carryerrvalmxh[0] n3 n1 vdd vssx ringpll__b15rt0022en1n02x5 m=1
Xu47 n42 p_abuf4 errvalmxh[21] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu51 n46 p_abuf4 carrymxh vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu45 n40 reg_req_ack__mashstateresetmxh errvalmxh[20] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu43 n38 reg_req_ack__mashstateresetmxh errvalmxh[19] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu41 n36 reg_req_ack__mashstateresetmxh errvalmxh[18] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu37 n32 reg_req_ack__mashstateresetmxh errvalmxh[16] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu35 n30 p_abuf3 errvalmxh[15] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu33 n28 reg_req_ack__mashstateresetmxh errvalmxh[14] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu31 n26 p_abuf5 errvalmxh[13] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu29 n24 p_abuf5 errvalmxh[12] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu27 n22 p_abuf5 errvalmxh[11] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu25 n20 p_abuf5 errvalmxh[10] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu23 n18 p_abuf5 errvalmxh[9] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu21 n16 p_abuf5 errvalmxh[8] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu19 n14 p_abuf5 errvalmxh[7] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu17 n12 p_abuf5 errvalmxh[6] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu15 n10 p_abuf5 errvalmxh[5] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu13 n8 p_abuf3 errvalmxh[4] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu11 n6 p_abuf3 errvalmxh[3] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu9 n4 p_abuf3 errvalmxh[2] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu7 n2 p_abuf3 errvalmxh[1] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu5 n1 p_abuf3 errvalmxh[0] vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu46 carryerrvalmxh[20] fractionmxh[20] n41 n43 n40 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu48 carryerrvalmxh[21] fractionmxh[21] n43 n45 n42 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu42 carryerrvalmxh[18] fractionmxh[18] n37 n39 n36 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu40 carryerrvalmxh[17] fractionmxh[17] n35 n37 n34 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu38 carryerrvalmxh[16] fractionmxh[16] n33 n35 n32 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu36 carryerrvalmxh[15] fractionmxh[15] n31 n33 n30 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu34 carryerrvalmxh[14] fractionmxh[14] n29 n31 n28 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu32 carryerrvalmxh[13] fractionmxh[13] n27 n29 n26 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu28 carryerrvalmxh[11] fractionmxh[11] n23 n25 n22 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu24 carryerrvalmxh[9] fractionmxh[9] n19 n21 n18 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu20 carryerrvalmxh[7] fractionmxh[7] n15 n17 n14 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu16 carryerrvalmxh[5] fractionmxh[5] n11 n13 n10 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu10 carryerrvalmxh[2] fractionmxh[2] n5 n7 n4 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu8 carryerrvalmxh[1] fractionmxh[1] n3 n5 n2 vdd vssx ringpll__b15rm0023al1n02x5 m=1
Xu30 carryerrvalmxh[12] fractionmxh[12] n25 n27 n24 vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu26 carryerrvalmxh[10] fractionmxh[10] n21 n23 n20 vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu22 carryerrvalmxh[8] fractionmxh[8] n17 n19 n16 vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu18 carryerrvalmxh[6] fractionmxh[6] n13 n15 n12 vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu14 carryerrvalmxh[4] fractionmxh[4] n9 n11 n8 vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu12 carryerrvalmxh[3] fractionmxh[3] n7 n9 n6 vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu49 n44 p_abuf4 errvalmxh[22] vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu39 n34 reg_req_ack__mashstateresetmxh errvalmxh[17] vdd vssx ringpll__b15nonb02an1n02x3 m=1
Xu50 carryerrvalmxh[22] fractionmxh[22] n45 n46 n44 vdd vssx ringpll__b15rm0023an1n02x5 m=1
Xu44 carryerrvalmxh[19] fractionmxh[19] n39 n41 n38 vdd vssx ringpll__b15rm0023an1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    clk2to1mux_2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__clk2to1mux_2 ckmuxout ckin1 ckin2 muxselect vdd vssx
* .PININFO ckin1:I ckin2:I muxselect:I vdd:I vssx:I ckmuxout:O
Xu2 muxselect ckin2 muxselect ckin1 ckmuxout vdd vssx ringpll__b15naoai3en1n08x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    clkgateen_0
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__clkgateen_0 gcenclkoutx gceninx gcteinx gcckinx vdd vssx
* .PININFO gcckinx:I gceninx:I gcteinx:I vdd:I vssx:I gcenclkoutx:O
Xctech_lib_clk_gate_te_rccu1 gcckinx gcenclkoutx gceninx gcteinx vdd vssx ringpll__b15cilb01al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    clkgateen_1
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__clkgateen_1 gcenclkoutx gceninx gcteinx gcckinx vdd vssx
* .PININFO gcckinx:I gceninx:I gcteinx:I vdd:I vssx:I gcenclkoutx:O
Xctech_lib_clk_gate_te_rccu1 gcckinx gcenclkoutx gceninx gcteinx vdd vssx ringpll__b15cilb01al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    startup_gen
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__startup_gen clkrefxxh reset_sync__reset_b_xxnnnl startup_gen__forcepullupxxh startup_gen__vctltrimenxxh startup_gen__vctlrdacenxxh startup_gen__pfdenxxh test_si test_sei vdd vssx p_abuf0 p63
* .PININFO clkrefxxh:I p63:I p_abuf0:I reset_sync__reset_b_xxnnnl:I test_sei:I test_si:I vdd:I vssx:I startup_gen__forcepullupxxh:O
* .PININFO startup_gen__pfdenxxh:O startup_gen__vctlrdacenxxh:O startup_gen__vctltrimenxxh:O
Xu997 net172 net431 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu584 test_si net172 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xpfden_1_reg clkrefxxh p63 pfden_1 reset_sync__reset_b_xxnnnl net431 test_sei vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xpfden_2_reg clkrefxxh pfden_1 startup_gen__pfdenxxh reset_sync__reset_b_xxnnnl pfden_1 p_abuf0 vdd vssx ringpll__b15fqy003al1n02x3 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljpllunitdly
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljpllunitdly dlyclkout clkin vccxx vssx
* .PININFO clkin:I vccxx:I vssx:I dlyclkout:O
Xbfm21 stg1 stg2 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xbfm20 clkin stg1 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xbfm22 stg2 stg3 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xbfm23 stg3 dlyclkout vccxx vssx ringpll__b15bfm201an1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_incprim
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_incprim cout digout cin cksduw1n00 inc load_b rst_b vccxx vssx
* .PININFO cin:I cksduw1n00:I inc:I load_b:I rst_b:I vccxx:I vssx:I cout:O digout:O
Xand00 rst_b load_b n18 n20 vccxx vssx ringpll__b15and003al1n02x5 m=1
Xdmfix_xor00 cin digout n18 vccxx vssx ringpll__b15xor002al1n02x5 m=1
Xand01 cin digout inc cout vccxx vssx ringpll__b15and003al1n03x5 m=1
Xfsn0 cksduw1n00 n20 digout vccxx vssx ringpll__b15fpn000al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_rstdly
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_rstdly dlyout dlyin vccdig vssx
* .PININFO dlyin:I vccdig:I vssx:I dlyout:O
Xbfn00 dlyin n1 vccdig vssx ringpll__b15bfn000al1n24x5 m=1
Xorn00 dlyin n3 dlyout vccdig vssx ringpll__b15orn002al1n08x5 m=1
Xires3 n2 n1 vssx ringpll__res_tfr_pcell_78
Xbfn01 n2 n3 vccdig vssx ringpll__b15bfn001al1n24x5 m=1
Xi5 vccdig n2 ringpll__pdecap_s2p_pcell_79
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_skadj_unit
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_skadj_unit lo ro sel li pre0b pre1b ri selprev vccxx vssx
* .PININFO li:I pre0b:I pre1b:I ri:I selprev:I vccxx:I vssx:I lo:O ro:O sel:O
Xoabi0 selprev pre0b pre1b sel vccxx vssx ringpll__b15oabi12al1n02x5 m=1
Xmbn01 ridel ro lo selprev vccxx vssx ringpll__b15mbn022al1n02x5 m=1
Xbfm40 ri ridel vccxx vssx ringpll__b15bfm402al1n02x5 m=1
Xispare vssx nc vccxx vssx ringpll__b15bfm402al1n02x5 m=1
Xand00 li sel ro vccxx vssx ringpll__b15and002al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_sures
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_sures vctl0 rtune[2] rtune[1] rtune[0] vccpll vr vssx
* .PININFO rtune[2]:I rtune[1]:I rtune[0]:I vccpll:I vr:I vssx:I vctl0:O
Xi248 vctl0 n3 rtune[2] vccpll vssx ringpll__pll_lfmux
Xi235 n3 n2 rtune[1] vccpll vssx ringpll__pll_lfmux
Xi6 n2 n1 rtune[0] vccpll vssx ringpll__pll_lfmux
Xi261 net11 vctl0 vccpll ringpll__res_tfr_pcell_100
Xi260 net12 net11 vccpll ringpll__res_tfr_pcell_100
Xi259 net13 net12 vccpll ringpll__res_tfr_pcell_100
Xi258 n3 net13 vccpll ringpll__res_tfr_pcell_100
Xi257 net14 n3 vccpll ringpll__res_tfr_pcell_100
Xi256 n2 net14 vccpll ringpll__res_tfr_pcell_100
Xi255 n1 n2 vccpll ringpll__res_tfr_pcell_100
Xi254 vr n1 vccpll ringpll__res_tfr_pcell_100
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_lf_res
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_lf_res rtrim[3] rtrim[2] rtrim[1] rtrim[0] vccpll vcp vctl0 vssx
* .PININFO rtrim[3]:I rtrim[2]:I rtrim[1]:I rtrim[0]:I vccpll:I vcp:I vctl0:I vssx:I
Xi22 n3 n4 rtrim[2] vccpll vssx ringpll__pll_lfmux
Xi23 n4 vctl0 rtrim[3] vccpll vssx ringpll__pll_lfmux
Xi11 n1 n2 rtrim[0] vccpll vssx ringpll__pll_lfmux
Xi17 n2 n3 rtrim[1] vccpll vssx ringpll__pll_lfmux
Xi12 n2 n1 vccpll ringpll__res_tfr_pcell_105
Xi13 n3 n2 vccpll ringpll__res_tfr_pcell_136
Xi14 n4 n3 vccpll ringpll__res_tfr_pcell_137
Xi15 n5 n4 vccpll ringpll__res_tfr_pcell_137
Xi38 n1 vcp vccpll ringpll__res_tfr_pcell_105
Xi16 vctl0 n5 vccpll ringpll__res_tfr_pcell_137
Xi26 n1 vcp vccpll ringpll__res_tfr_pcell_105
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_viewmux8
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_viewmux8 vout sel[2] sel[1] sel[0] v0 v1 v2 v3 v4 v5 v6 v7 vccpll vssx
* .PININFO sel[2]:I sel[1]:I sel[0]:I v0:I v1:I v2:I v3:I v4:I v5:I v6:I v7:I vccpll:I vssx:I vout:O
Xbfm20[2] sel[2] seli[2] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfm20[1] sel[1] seli[1] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfm20[0] sel[0] seli[0] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xmbn00 n3 n4 n6 seli[1] vccpll vssx ringpll__b15mdn022al1n04x5 m=1
Xmbn017 n1 n2 n5 seli[1] vccpll vssx ringpll__b15mdn022al1n04x5 m=1
Xmbn04 v1 v0 n4 seli[0] vccpll vssx ringpll__b15mdn022al1n04x5 m=1
Xmbn03 v3 v2 n3 seli[0] vccpll vssx ringpll__b15mdn022al1n04x5 m=1
Xmbn02 v5 v4 n2 seli[0] vccpll vssx ringpll__b15mdn022al1n04x5 m=1
Xmbn01 v7 v6 n1 seli[0] vccpll vssx ringpll__b15mdn022al1n04x5 m=1
Xmbn05 n5 n6 vout seli[2] vccpll vssx ringpll__b15mbn022al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_cnlx74ljpllunitdly
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_cnlx74ljpllunitdly dlyclkout clkin vccxx vssx
* .PININFO clkin:I vccxx:I vssx:I dlyclkout:O
Xbfm40 clkin stg1 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xbfm45 stg5 stg6 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xbfm41 stg1 stg2 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xbfm42 stg2 stg3 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xbfm21 stg7 dlyclkout vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xbfm43 stg3 stg4 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xbfm44 stg4 stg5 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xbfm46 stg6 stg7 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_anamuxtg
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_anamuxtg aout ain en vccvdd2 vccxx vssx
* .PININFO ain:I en:I vccvdd2:I vccxx:I vssx:I aout:B
Xsg000 en vssx eni vccxx vccvdd2 vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Mmn1 enb eni vssx vssx ntg W=180n L=160n M=1
Mmn0 ain eni aout vssx ntg W=360n L=160n M=8
Mmp0 ain enb aout vccvdd2 ptg W=360n L=160n M=8
Mmp1 enb eni vccvdd2 vccvdd2 ptg W=180n L=160n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22lpldo_cnt_bit
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22lpldo_cnt_bit dmfix_out clk rb vccx vssx
* .PININFO clk:I rb:I vccx:I vssx:I dmfix_out:O
Xfan00 dmfix_out vccx vssx clk o_d vssx rb vssx ringpll__xb15fan07bxl1n08x5
Xbfm01 o_d vccx vssx dmfix_out ringpll__xb15bfm201xl1n02x5
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_outbuf_ln
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_outbuf_ln o a vccx vssx
* .PININFO a:I vccx:I vssx:I o:O
Xbfn00 a o vccx vssx ringpll__b15bfn001al1n12x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_esdd3d4
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_esdd3d4 dft_anapad dft_anain vccx vssx
* .PININFO dft_anain:I vccx:I vssx:I dft_anapad:O
Xi3 rint dft_anapad vssx ringpll__res_tfr_pcell_102
Xiesdres dft_anain rint vssx ringpll__res_tfr_pcell_102
Xid3[2] dft_anain vssx b88xesddjnu6ogdxnxcnx
Xid3[1] dft_anain vssx b88xesddjnu6ogdxnxcnx
Xid4[2] dft_anain vccx b88xesddjpu6ogdxnxcnx
Xid4[1] dft_anain vccx b88xesddjpu6ogdxnxcnx
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_res_10k
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_res_10k a b vssx
* .PININFO vssx:I a:B b:B
Xires3 mi4 mid3 vssx ringpll__res_tfr_dnw_pcell_0
Xires5 mi4 mid5 vssx ringpll__res_tfr_dnw_pcell_1
Xires1 a mid1 vssx ringpll__res_tfr_dnw_pcell_2
Xires6 mid5 b vssx ringpll__res_tfr_dnw_pcell_3
Xires4 mid3 mid2 vssx ringpll__res_tfr_dnw_pcell_4
Xires2 mid1 mid2 vssx ringpll__res_tfr_dnw_pcell_5
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_lpf_topres
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_lpf_topres bottom top vssx
* .PININFO vssx:I bottom:B top:B
Xires3 res_mid top vssx ringpll__res_tfr_dnw_pcell_9
Xires2 bottom res_mid vssx ringpll__res_tfr_dnw_pcell_10
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_res_1p6k
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_res_1p6k a b vssx
* .PININFO a:B b:B vssx:B
Xires1 a b vssx ringpll__res_tfr_dnw_pcell_2
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22ldo_ampcompensation
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22ldo_ampcompensation comp_in comp_out
* .PININFO comp_in:I comp_out:I
Xiccap2 comp_out comp_mid ringpll__pdecap_s2p_pcell_27
Xires5 comp_in comp_mid comp_out ringpll__res_tfr_pcell_28
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljplldac_res_cell
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljplldac_res_cell a b nwl
* .PININFO a:B b:B nwl:B
Xires1 a b nwl ringpll__res_tfr_pcell_103
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_lfc1
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_lfc1 vccpll vctl0 vssx
* .PININFO vccpll:I vctl0:I vssx:I
Xi3 vctl0 vccpll vssx ringpll__mfc_s2p_pcell_138
Xic1 vctl0 vccpll vssx ringpll__mfc_s2p_pcell_139
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ip22_topdecap2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ip22_topdecap2 vccpll_nom vssx
* .PININFO vccpll_nom:I vssx:I
Xidecap vccpll_nom vssx ringpll__pdecap_s2p_pcell_179
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ip22_topdecap1
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ip22_topdecap1 vccpll_nom vssx
* .PININFO vccpll_nom:I vssx:I
Xidecap vccpll_nom vssx ringpll__pdecap_s2p_pcell_40
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ip22_topdecap_new_extra
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ip22_topdecap_new_extra vccpll_nom vssx
* .PININFO vccpll_nom:I vssx:I
Xi3 vccpll_nom vssx ringpll__pdecap_s2p_pcell_180
Xidecap vccpll_nom vssx ringpll__pdecap_s2p_pcell_181
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22ldo_decap1
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22ldo_decap1 vccpll vssx
* .PININFO vccpll:I vssx:I
Xidecap11 vccpll vssx ringpll__pdecap_s2p_pcell_22
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22ldo_decap3
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22ldo_decap3 vccpll vssx
* .PININFO vccpll:I vssx:I
Xidecap13 vccpll vssx ringpll__pdecap_s2p_pcell_23
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22ldo_decap2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22ldo_decap2 vccpll vssx
* .PININFO vccpll:I vssx:I
Xidecap12 vccpll vssx ringpll__pdecap_s2p_pcell_25
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_interface_icf
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_interface_icf bypass_i clkpll clkpll0 clkpll1 clkpostdist_i clkref_i clkref_to_ana fraction_i[23] fraction_i[22] fraction_i[21] fraction_i[20] fraction_i[19] fraction_i[18] fraction_i[17] fraction_i[16] fraction_i[15] fraction_i[14] fraction_i[13] fraction_i[12] fraction_i[11] fraction_i[10] fraction_i[9] fraction_i[8] fraction_i[7] fraction_i[6] fraction_i[5] fraction_i[4] fraction_i[3] fraction_i[2] fraction_i[1] fraction_i[0] fz_cp1trim_i[4] fz_cp1trim_i[3] fz_cp1trim_i[2] fz_cp1trim_i[1] fz_cp1trim_i[0] fz_cp2trim_i[4] fz_cp2trim_i[3] fz_cp2trim_i[2] fz_cp2trim_i[1] fz_cp2trim_i[0] fz_cpnbias_i[1] fz_cpnbias_i[0] fz_dca_cb_i[1] fz_dca_cb_i[0] fz_dca_ctrl_i[5] fz_dca_ctrl_i[4] fz_dca_ctrl_i[3] fz_dca_ctrl_i[2] fz_dca_ctrl_i[1] fz_dca_ctrl_i[0] fz_irefgen_i[4] fz_irefgen_i[3] fz_irefgen_i[2] fz_irefgen_i[1] fz_irefgen_i[0] fz_ldo_bypass_i fz_ldo_extrefsel_i fz_ldo_faststart_i fz_ldo_fbtrim_i[3] fz_ldo_fbtrim_i[2] fz_ldo_fbtrim_i[1] fz_ldo_fbtrim_i[0] fz_ldo_reftrim_i[3] fz_ldo_reftrim_i[2] fz_ldo_reftrim_i[1] fz_ldo_reftrim_i[0] fz_ldo_vinvoltsel_i[1] fz_ldo_vinvoltsel_i[0] fz_lockcnt_i[2] fz_lockcnt_i[1] fz_lockcnt_i[0] fz_lockforce_i fz_lockstickyb_i fz_lockthresh_i[3] fz_lockthresh_i[2] fz_lockthresh_i[1] fz_lockthresh_i[0] fz_lpfclksel_i fz_nopfdpwrgate_i fz_pfd_pw_i[2] fz_pfd_pw_i[1] fz_pfd_pw_i[0] fz_pfddly_i[1] fz_pfddly_i[0] fz_skadj_i[4] fz_skadj_i[3] fz_skadj_i[2] fz_skadj_i[1] fz_skadj_i[0] fz_spare_i[4] fz_spare_i[3] fz_spare_i[2] fz_spare_i[1] fz_spare_i[0] fz_startup_i[5] fz_startup_i[4] fz_startup_i[3] fz_startup_i[2] fz_startup_i[1] fz_startup_i[0] fz_tight_loopb_i fz_vcosel_i fz_vcotrim_i[10] fz_vcotrim_i[9] fz_vcotrim_i[8] fz_vcotrim_i[7] fz_vcotrim_i[6] fz_vcotrim_i[5] fz_vcotrim_i[4] fz_vcotrim_i[3] fz_vcotrim_i[2] fz_vcotrim_i[1] fz_vcotrim_i[0] idfx_fscan_byprstb_i idfx_fscan_clkungate_i idfx_fscan_mode_i idfx_fscan_rstbypen_i idfx_fscan_sdi_i[2] idfx_fscan_sdi_i[1] idfx_fscan_sdi_i[0] idfx_fscan_shiften_i idvdisable_bi_i idvdisable_bo idvfreqai_i idvfreqao idvfreqbi_i idvfreqbo idvpulsei_i idvpulseo idvtclki_i idvtclko idvtctrli_i idvtctrlo idvtdi_i idvtdo idvtresi_i idvtreso ldo_enable_i lock mash_order_plus_one_i mdiv_ratio_i[5] mdiv_ratio_i[4] mdiv_ratio_i[3] mdiv_ratio_i[2] mdiv_ratio_i[1] mdiv_ratio_i[0] odfx_fscan_sdo[2] odfx_fscan_sdo[1] odfx_fscan_sdo[0] pllen_i pllfwen_b_i powergood_vccdig powergood_vnn_buf ratio_i[9] ratio_i[8] ratio_i[7] ratio_i[6] ratio_i[5] ratio_i[4] ratio_i[3] ratio_i[2] ratio_i[1] ratio_i[0] ssc_cyc_to_peak_m1_i[8] ssc_cyc_to_peak_m1_i[7] ssc_cyc_to_peak_m1_i[6] ssc_cyc_to_peak_m1_i[5] ssc_cyc_to_peak_m1_i[4] ssc_cyc_to_peak_m1_i[3] ssc_cyc_to_peak_m1_i[2] ssc_cyc_to_peak_m1_i[1] ssc_cyc_to_peak_m1_i[0] ssc_en_i ssc_frac_step_i[23] ssc_frac_step_i[22] ssc_frac_step_i[21] ssc_frac_step_i[20] ssc_frac_step_i[19] ssc_frac_step_i[18] ssc_frac_step_i[17] ssc_frac_step_i[16] ssc_frac_step_i[15] ssc_frac_step_i[14] ssc_frac_step_i[13] ssc_frac_step_i[12] ssc_frac_step_i[11] ssc_frac_step_i[10] ssc_frac_step_i[9] ssc_frac_step_i[8] ssc_frac_step_i[7] ssc_frac_step_i[6] ssc_frac_step_i[5] ssc_frac_step_i[4] ssc_frac_step_i[3] ssc_frac_step_i[2] ssc_frac_step_i[1] ssc_frac_step_i[0] tcapturedr_i tck_i tdi_i tdo treg_en_i trst_n_i tshiftdr_i tupdatedr_i vcodiv_ratio_i[1] vcodiv_ratio_i[0] view_dig_out[1] view_dig_out[0] zdiv0_ratio_i[9] zdiv0_ratio_i[8] zdiv0_ratio_i[7] zdiv0_ratio_i[6] zdiv0_ratio_i[5] zdiv0_ratio_i[4] zdiv0_ratio_i[3] zdiv0_ratio_i[2] zdiv0_ratio_i[1] zdiv0_ratio_i[0] zdiv0_ratio_p5_i zdiv1_ratio_i[9] zdiv1_ratio_i[8] zdiv1_ratio_i[7] zdiv1_ratio_i[6] zdiv1_ratio_i[5] zdiv1_ratio_i[4] zdiv1_ratio_i[3] zdiv1_ratio_i[2] zdiv1_ratio_i[1] zdiv1_ratio_i[0] zdiv1_ratio_p5_i bypass clkpll0_i clkpll1_i clkpll_i clkpostdist clkref fraction[23] fraction[22] fraction[21] fraction[20] fraction[19] fraction[18] fraction[17] fraction[16] fraction[15] fraction[14] fraction[13] fraction[12] fraction[11] fraction[10] fraction[9] fraction[8] fraction[7] fraction[6] fraction[5] fraction[4] fraction[3] fraction[2] fraction[1] fraction[0] fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] fz_cpnbias[1] fz_cpnbias[0] fz_dca_cb[1] fz_dca_cb[0] fz_dca_ctrl[5] fz_dca_ctrl[4] fz_dca_ctrl[3] fz_dca_ctrl[2] fz_dca_ctrl[1] fz_dca_ctrl[0] fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] fz_ldo_bypass fz_ldo_extrefsel fz_ldo_faststart fz_ldo_fbtrim[3] fz_ldo_fbtrim[2] fz_ldo_fbtrim[1] fz_ldo_fbtrim[0] fz_ldo_reftrim[3] fz_ldo_reftrim[2] fz_ldo_reftrim[1] fz_ldo_reftrim[0] fz_ldo_vinvoltsel[1] fz_ldo_vinvoltsel[0] fz_lockcnt[2] fz_lockcnt[1] fz_lockcnt[0] fz_lockforce fz_lockstickyb fz_lockthresh[3] fz_lockthresh[2] fz_lockthresh[1] fz_lockthresh[0] fz_lpfclksel fz_nopfdpwrgate fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] fz_pfddly[1] fz_pfddly[0] fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] fz_spare[4] fz_spare[3] fz_spare[2] fz_spare[1] fz_spare[0] fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] fz_tight_loopb fz_vcosel fz_vcotrim[10] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] idfx_fscan_byprstb idfx_fscan_clkungate idfx_fscan_mode idfx_fscan_rstbypen idfx_fscan_sdi[2] idfx_fscan_sdi[1] idfx_fscan_sdi[0] idfx_fscan_shiften idvdisable_bi idvdisable_bo_i idvfreqai idvfreqao_i idvfreqbi idvfreqbo_i idvpulsei idvpulseo_i idvtclki idvtclko_i idvtctrli idvtctrlo_i idvtdi idvtdo_i idvtresi idvtreso_i ldo_enable lock_i mash_order_plus_one mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] odfx_fscan_sdo_i[2] odfx_fscan_sdo_i[1] odfx_fscan_sdo_i[0] pllen pllfwen_b powergood_vnn ratio[9] ratio[8] ratio[7] ratio[6] ratio[5] ratio[4] ratio[3] ratio[2] ratio[1] ratio[0] ssc_cyc_to_peak_m1[8] ssc_cyc_to_peak_m1[7] ssc_cyc_to_peak_m1[6] ssc_cyc_to_peak_m1[5] ssc_cyc_to_peak_m1[4] ssc_cyc_to_peak_m1[3] ssc_cyc_to_peak_m1[2] ssc_cyc_to_peak_m1[1] ssc_cyc_to_peak_m1[0] ssc_en ssc_frac_step[23] ssc_frac_step[22] ssc_frac_step[21] ssc_frac_step[20] ssc_frac_step[19] ssc_frac_step[18] ssc_frac_step[17] ssc_frac_step[16] ssc_frac_step[15] ssc_frac_step[14] ssc_frac_step[13] ssc_frac_step[12] ssc_frac_step[11] ssc_frac_step[10] ssc_frac_step[9] ssc_frac_step[8] ssc_frac_step[7] ssc_frac_step[6] ssc_frac_step[5] ssc_frac_step[4] ssc_frac_step[3] ssc_frac_step[2] ssc_frac_step[1] ssc_frac_step[0] tcapturedr tck tdi tdo_i treg_en trst_n tshiftdr tupdatedr vccdig vccdist vcodiv_ratio[1] vcodiv_ratio[0] view_dig_out_i[1] view_dig_out_i[0] vnnaon vssx zdiv0_ratio[9] zdiv0_ratio[8] zdiv0_ratio[7] zdiv0_ratio[6] zdiv0_ratio[5] zdiv0_ratio[4] zdiv0_ratio[3] zdiv0_ratio[2] zdiv0_ratio[1] zdiv0_ratio[0] zdiv0_ratio_p5 zdiv1_ratio[9] zdiv1_ratio[8] zdiv1_ratio[7] zdiv1_ratio[6] zdiv1_ratio[5] zdiv1_ratio[4] zdiv1_ratio[3] zdiv1_ratio[2] zdiv1_ratio[1] zdiv1_ratio[0] zdiv1_ratio_p5
* .PININFO bypass:I clkpll0_i:I clkpll1_i:I clkpll_i:I clkpostdist:I clkref:I fraction[23]:I fraction[22]:I fraction[21]:I fraction[20]:I
* .PININFO fraction[19]:I fraction[18]:I fraction[17]:I fraction[16]:I fraction[15]:I fraction[14]:I fraction[13]:I fraction[12]:I fraction[11]:I
* .PININFO fraction[10]:I fraction[9]:I fraction[8]:I fraction[7]:I fraction[6]:I fraction[5]:I fraction[4]:I fraction[3]:I fraction[2]:I
* .PININFO fraction[1]:I fraction[0]:I fz_cp1trim[4]:I fz_cp1trim[3]:I fz_cp1trim[2]:I fz_cp1trim[1]:I fz_cp1trim[0]:I fz_cp2trim[4]:I fz_cp2trim[3]:I
* .PININFO fz_cp2trim[2]:I fz_cp2trim[1]:I fz_cp2trim[0]:I fz_cpnbias[1]:I fz_cpnbias[0]:I fz_dca_cb[1]:I fz_dca_cb[0]:I fz_dca_ctrl[5]:I
* .PININFO fz_dca_ctrl[4]:I fz_dca_ctrl[3]:I fz_dca_ctrl[2]:I fz_dca_ctrl[1]:I fz_dca_ctrl[0]:I fz_irefgen[4]:I fz_irefgen[3]:I fz_irefgen[2]:I
* .PININFO fz_irefgen[1]:I fz_irefgen[0]:I fz_ldo_bypass:I fz_ldo_extrefsel:I fz_ldo_faststart:I fz_ldo_fbtrim[3]:I fz_ldo_fbtrim[2]:I
* .PININFO fz_ldo_fbtrim[1]:I fz_ldo_fbtrim[0]:I fz_ldo_reftrim[3]:I fz_ldo_reftrim[2]:I fz_ldo_reftrim[1]:I fz_ldo_reftrim[0]:I
* .PININFO fz_ldo_vinvoltsel[1]:I fz_ldo_vinvoltsel[0]:I fz_lockcnt[2]:I fz_lockcnt[1]:I fz_lockcnt[0]:I fz_lockforce:I fz_lockstickyb:I
* .PININFO fz_lockthresh[3]:I fz_lockthresh[2]:I fz_lockthresh[1]:I fz_lockthresh[0]:I fz_lpfclksel:I fz_nopfdpwrgate:I fz_pfd_pw[2]:I fz_pfd_pw[1]:I
* .PININFO fz_pfd_pw[0]:I fz_pfddly[1]:I fz_pfddly[0]:I fz_skadj[4]:I fz_skadj[3]:I fz_skadj[2]:I fz_skadj[1]:I fz_skadj[0]:I fz_spare[4]:I
* .PININFO fz_spare[3]:I fz_spare[2]:I fz_spare[1]:I fz_spare[0]:I fz_startup[5]:I fz_startup[4]:I fz_startup[3]:I fz_startup[2]:I fz_startup[1]:I
* .PININFO fz_startup[0]:I fz_tight_loopb:I fz_vcosel:I fz_vcotrim[10]:I fz_vcotrim[9]:I fz_vcotrim[8]:I fz_vcotrim[7]:I fz_vcotrim[6]:I
* .PININFO fz_vcotrim[5]:I fz_vcotrim[4]:I fz_vcotrim[3]:I fz_vcotrim[2]:I fz_vcotrim[1]:I fz_vcotrim[0]:I idfx_fscan_byprstb:I idfx_fscan_clkungate:I
* .PININFO idfx_fscan_mode:I idfx_fscan_rstbypen:I idfx_fscan_sdi[2]:I idfx_fscan_sdi[1]:I idfx_fscan_sdi[0]:I idfx_fscan_shiften:I idvdisable_bi:I
* .PININFO idvdisable_bo_i:I idvfreqai:I idvfreqao_i:I idvfreqbi:I idvfreqbo_i:I idvpulsei:I idvpulseo_i:I idvtclki:I idvtclko_i:I idvtctrli:I
* .PININFO idvtctrlo_i:I idvtdi:I idvtdo_i:I idvtresi:I idvtreso_i:I ldo_enable:I lock_i:I mash_order_plus_one:I mdiv_ratio[5]:I mdiv_ratio[4]:I
* .PININFO mdiv_ratio[3]:I mdiv_ratio[2]:I mdiv_ratio[1]:I mdiv_ratio[0]:I odfx_fscan_sdo_i[2]:I odfx_fscan_sdo_i[1]:I odfx_fscan_sdo_i[0]:I pllen:I
* .PININFO pllfwen_b:I powergood_vnn:I ratio[9]:I ratio[8]:I ratio[7]:I ratio[6]:I ratio[5]:I ratio[4]:I ratio[3]:I ratio[2]:I ratio[1]:I ratio[0]:I
* .PININFO ssc_cyc_to_peak_m1[8]:I ssc_cyc_to_peak_m1[7]:I ssc_cyc_to_peak_m1[6]:I ssc_cyc_to_peak_m1[5]:I ssc_cyc_to_peak_m1[4]:I
* .PININFO ssc_cyc_to_peak_m1[3]:I ssc_cyc_to_peak_m1[2]:I ssc_cyc_to_peak_m1[1]:I ssc_cyc_to_peak_m1[0]:I ssc_en:I ssc_frac_step[23]:I
* .PININFO ssc_frac_step[22]:I ssc_frac_step[21]:I ssc_frac_step[20]:I ssc_frac_step[19]:I ssc_frac_step[18]:I ssc_frac_step[17]:I ssc_frac_step[16]:I
* .PININFO ssc_frac_step[15]:I ssc_frac_step[14]:I ssc_frac_step[13]:I ssc_frac_step[12]:I ssc_frac_step[11]:I ssc_frac_step[10]:I ssc_frac_step[9]:I
* .PININFO ssc_frac_step[8]:I ssc_frac_step[7]:I ssc_frac_step[6]:I ssc_frac_step[5]:I ssc_frac_step[4]:I ssc_frac_step[3]:I ssc_frac_step[2]:I
* .PININFO ssc_frac_step[1]:I ssc_frac_step[0]:I tcapturedr:I tck:I tdi:I tdo_i:I treg_en:I trst_n:I tshiftdr:I tupdatedr:I vccdig:I vccdist:I
* .PININFO vcodiv_ratio[1]:I vcodiv_ratio[0]:I view_dig_out_i[1]:I view_dig_out_i[0]:I vnnaon:I vssx:I zdiv0_ratio[9]:I zdiv0_ratio[8]:I
* .PININFO zdiv0_ratio[7]:I zdiv0_ratio[6]:I zdiv0_ratio[5]:I zdiv0_ratio[4]:I zdiv0_ratio[3]:I zdiv0_ratio[2]:I zdiv0_ratio[1]:I zdiv0_ratio[0]:I
* .PININFO zdiv0_ratio_p5:I zdiv1_ratio[9]:I zdiv1_ratio[8]:I zdiv1_ratio[7]:I zdiv1_ratio[6]:I zdiv1_ratio[5]:I zdiv1_ratio[4]:I zdiv1_ratio[3]:I
* .PININFO zdiv1_ratio[2]:I zdiv1_ratio[1]:I zdiv1_ratio[0]:I zdiv1_ratio_p5:I bypass_i:O clkpll:O clkpll0:O clkpll1:O clkpostdist_i:O clkref_i:O
* .PININFO clkref_to_ana:O fraction_i[23]:O fraction_i[22]:O fraction_i[21]:O fraction_i[20]:O fraction_i[19]:O fraction_i[18]:O fraction_i[17]:O
* .PININFO fraction_i[16]:O fraction_i[15]:O fraction_i[14]:O fraction_i[13]:O fraction_i[12]:O fraction_i[11]:O fraction_i[10]:O fraction_i[9]:O
* .PININFO fraction_i[8]:O fraction_i[7]:O fraction_i[6]:O fraction_i[5]:O fraction_i[4]:O fraction_i[3]:O fraction_i[2]:O fraction_i[1]:O
* .PININFO fraction_i[0]:O fz_cp1trim_i[4]:O fz_cp1trim_i[3]:O fz_cp1trim_i[2]:O fz_cp1trim_i[1]:O fz_cp1trim_i[0]:O fz_cp2trim_i[4]:O
* .PININFO fz_cp2trim_i[3]:O fz_cp2trim_i[2]:O fz_cp2trim_i[1]:O fz_cp2trim_i[0]:O fz_cpnbias_i[1]:O fz_cpnbias_i[0]:O fz_dca_cb_i[1]:O
* .PININFO fz_dca_cb_i[0]:O fz_dca_ctrl_i[5]:O fz_dca_ctrl_i[4]:O fz_dca_ctrl_i[3]:O fz_dca_ctrl_i[2]:O fz_dca_ctrl_i[1]:O fz_dca_ctrl_i[0]:O
* .PININFO fz_irefgen_i[4]:O fz_irefgen_i[3]:O fz_irefgen_i[2]:O fz_irefgen_i[1]:O fz_irefgen_i[0]:O fz_ldo_bypass_i:O fz_ldo_extrefsel_i:O
* .PININFO fz_ldo_faststart_i:O fz_ldo_fbtrim_i[3]:O fz_ldo_fbtrim_i[2]:O fz_ldo_fbtrim_i[1]:O fz_ldo_fbtrim_i[0]:O fz_ldo_reftrim_i[3]:O
* .PININFO fz_ldo_reftrim_i[2]:O fz_ldo_reftrim_i[1]:O fz_ldo_reftrim_i[0]:O fz_ldo_vinvoltsel_i[1]:O fz_ldo_vinvoltsel_i[0]:O fz_lockcnt_i[2]:O
* .PININFO fz_lockcnt_i[1]:O fz_lockcnt_i[0]:O fz_lockforce_i:O fz_lockstickyb_i:O fz_lockthresh_i[3]:O fz_lockthresh_i[2]:O fz_lockthresh_i[1]:O
* .PININFO fz_lockthresh_i[0]:O fz_lpfclksel_i:O fz_nopfdpwrgate_i:O fz_pfd_pw_i[2]:O fz_pfd_pw_i[1]:O fz_pfd_pw_i[0]:O fz_pfddly_i[1]:O
* .PININFO fz_pfddly_i[0]:O fz_skadj_i[4]:O fz_skadj_i[3]:O fz_skadj_i[2]:O fz_skadj_i[1]:O fz_skadj_i[0]:O fz_spare_i[4]:O fz_spare_i[3]:O
* .PININFO fz_spare_i[2]:O fz_spare_i[1]:O fz_spare_i[0]:O fz_startup_i[5]:O fz_startup_i[4]:O fz_startup_i[3]:O fz_startup_i[2]:O fz_startup_i[1]:O
* .PININFO fz_startup_i[0]:O fz_tight_loopb_i:O fz_vcosel_i:O fz_vcotrim_i[10]:O fz_vcotrim_i[9]:O fz_vcotrim_i[8]:O fz_vcotrim_i[7]:O
* .PININFO fz_vcotrim_i[6]:O fz_vcotrim_i[5]:O fz_vcotrim_i[4]:O fz_vcotrim_i[3]:O fz_vcotrim_i[2]:O fz_vcotrim_i[1]:O fz_vcotrim_i[0]:O
* .PININFO idfx_fscan_byprstb_i:O idfx_fscan_clkungate_i:O idfx_fscan_mode_i:O idfx_fscan_rstbypen_i:O idfx_fscan_sdi_i[2]:O idfx_fscan_sdi_i[1]:O
* .PININFO idfx_fscan_sdi_i[0]:O idfx_fscan_shiften_i:O idvdisable_bi_i:O idvdisable_bo:O idvfreqai_i:O idvfreqao:O idvfreqbi_i:O idvfreqbo:O
* .PININFO idvpulsei_i:O idvpulseo:O idvtclki_i:O idvtclko:O idvtctrli_i:O idvtctrlo:O idvtdi_i:O idvtdo:O idvtresi_i:O idvtreso:O ldo_enable_i:O
* .PININFO lock:O mash_order_plus_one_i:O mdiv_ratio_i[5]:O mdiv_ratio_i[4]:O mdiv_ratio_i[3]:O mdiv_ratio_i[2]:O mdiv_ratio_i[1]:O mdiv_ratio_i[0]:O
* .PININFO odfx_fscan_sdo[2]:O odfx_fscan_sdo[1]:O odfx_fscan_sdo[0]:O pllen_i:O pllfwen_b_i:O powergood_vccdig:O powergood_vnn_buf:O ratio_i[9]:O
* .PININFO ratio_i[8]:O ratio_i[7]:O ratio_i[6]:O ratio_i[5]:O ratio_i[4]:O ratio_i[3]:O ratio_i[2]:O ratio_i[1]:O ratio_i[0]:O
* .PININFO ssc_cyc_to_peak_m1_i[8]:O ssc_cyc_to_peak_m1_i[7]:O ssc_cyc_to_peak_m1_i[6]:O ssc_cyc_to_peak_m1_i[5]:O ssc_cyc_to_peak_m1_i[4]:O
* .PININFO ssc_cyc_to_peak_m1_i[3]:O ssc_cyc_to_peak_m1_i[2]:O ssc_cyc_to_peak_m1_i[1]:O ssc_cyc_to_peak_m1_i[0]:O ssc_en_i:O ssc_frac_step_i[23]:O
* .PININFO ssc_frac_step_i[22]:O ssc_frac_step_i[21]:O ssc_frac_step_i[20]:O ssc_frac_step_i[19]:O ssc_frac_step_i[18]:O ssc_frac_step_i[17]:O
* .PININFO ssc_frac_step_i[16]:O ssc_frac_step_i[15]:O ssc_frac_step_i[14]:O ssc_frac_step_i[13]:O ssc_frac_step_i[12]:O ssc_frac_step_i[11]:O
* .PININFO ssc_frac_step_i[10]:O ssc_frac_step_i[9]:O ssc_frac_step_i[8]:O ssc_frac_step_i[7]:O ssc_frac_step_i[6]:O ssc_frac_step_i[5]:O
* .PININFO ssc_frac_step_i[4]:O ssc_frac_step_i[3]:O ssc_frac_step_i[2]:O ssc_frac_step_i[1]:O ssc_frac_step_i[0]:O tcapturedr_i:O tck_i:O tdi_i:O
* .PININFO tdo:O treg_en_i:O trst_n_i:O tshiftdr_i:O tupdatedr_i:O vcodiv_ratio_i[1]:O vcodiv_ratio_i[0]:O view_dig_out[1]:O view_dig_out[0]:O
* .PININFO zdiv0_ratio_i[9]:O zdiv0_ratio_i[8]:O zdiv0_ratio_i[7]:O zdiv0_ratio_i[6]:O zdiv0_ratio_i[5]:O zdiv0_ratio_i[4]:O zdiv0_ratio_i[3]:O
* .PININFO zdiv0_ratio_i[2]:O zdiv0_ratio_i[1]:O zdiv0_ratio_i[0]:O zdiv0_ratio_p5_i:O zdiv1_ratio_i[9]:O zdiv1_ratio_i[8]:O zdiv1_ratio_i[7]:O
* .PININFO zdiv1_ratio_i[6]:O zdiv1_ratio_i[5]:O zdiv1_ratio_i[4]:O zdiv1_ratio_i[3]:O zdiv1_ratio_i[2]:O zdiv1_ratio_i[1]:O zdiv1_ratio_i[0]:O
* .PININFO zdiv1_ratio_p5_i:O
Xi182 clkref_i clkref_to_ana clkref vccdig vssx ringpll__pll_inbuf_hn_clk
Xi173 clkpost_nc clkpostdist_i clkpostdist vccdist vssx ringpll__pll_inbuf_hn_clk
Xi250 clkpll1_i clkpll1 vccdist vssx ringpll__pll_outbuf_hn_clk
Xi249 clkpll0_i clkpll0 vccdist vssx ringpll__pll_outbuf_hn_clk
Xi248 clkpll_i clkpll vccdist vssx ringpll__pll_outbuf_hn_clk
Xi237[1] view_dig_out[1] view_dig_out_i[1] vccdig vssx ringpll__pll_outbuf_ln
Xi237[0] view_dig_out[0] view_dig_out_i[0] vccdig vssx ringpll__pll_outbuf_ln
Xi260[2] odfx_fscan_sdo[2] odfx_fscan_sdo_i[2] vccdig vssx ringpll__pll_outbuf_ln
Xi260[1] odfx_fscan_sdo[1] odfx_fscan_sdo_i[1] vccdig vssx ringpll__pll_outbuf_ln
Xi260[0] odfx_fscan_sdo[0] odfx_fscan_sdo_i[0] vccdig vssx ringpll__pll_outbuf_ln
Xi241 idvfreqao idvfreqao_i vccdig vssx ringpll__pll_outbuf_ln
Xi242 idvtclko idvtclko_i vccdig vssx ringpll__pll_outbuf_ln
Xi243 idvtctrlo idvtctrlo_i vccdig vssx ringpll__pll_outbuf_ln
Xi244 idvtdo idvtdo_i vccdig vssx ringpll__pll_outbuf_ln
Xi246 tdo tdo_i vccdig vssx ringpll__pll_outbuf_ln
Xi236 lock lock_i vccdig vssx ringpll__pll_outbuf_ln
Xi238 idvdisable_bo idvdisable_bo_i vccdig vssx ringpll__pll_outbuf_ln
Xi239 idvpulseo idvpulseo_i vccdig vssx ringpll__pll_outbuf_ln
Xi240 idvfreqbo idvfreqbo_i vccdig vssx ringpll__pll_outbuf_ln
Xi247 idvtreso idvtreso_i vccdig vssx ringpll__pll_outbuf_ln
Xi191[4] fz_cp2trim_i[4] fz_cp2trim[4] vccdig vssx ringpll__pll_inbuf_ln
Xi191[3] fz_cp2trim_i[3] fz_cp2trim[3] vccdig vssx ringpll__pll_inbuf_ln
Xi191[2] fz_cp2trim_i[2] fz_cp2trim[2] vccdig vssx ringpll__pll_inbuf_ln
Xi191[1] fz_cp2trim_i[1] fz_cp2trim[1] vccdig vssx ringpll__pll_inbuf_ln
Xi191[0] fz_cp2trim_i[0] fz_cp2trim[0] vccdig vssx ringpll__pll_inbuf_ln
Xi208[5] fz_dca_ctrl_i[5] fz_dca_ctrl[5] vccdig vssx ringpll__pll_inbuf_ln
Xi208[4] fz_dca_ctrl_i[4] fz_dca_ctrl[4] vccdig vssx ringpll__pll_inbuf_ln
Xi208[3] fz_dca_ctrl_i[3] fz_dca_ctrl[3] vccdig vssx ringpll__pll_inbuf_ln
Xi208[2] fz_dca_ctrl_i[2] fz_dca_ctrl[2] vccdig vssx ringpll__pll_inbuf_ln
Xi208[1] fz_dca_ctrl_i[1] fz_dca_ctrl[1] vccdig vssx ringpll__pll_inbuf_ln
Xi208[0] fz_dca_ctrl_i[0] fz_dca_ctrl[0] vccdig vssx ringpll__pll_inbuf_ln
Xi213[1] fz_dca_cb_i[1] fz_dca_cb[1] vccdig vssx ringpll__pll_inbuf_ln
Xi213[0] fz_dca_cb_i[0] fz_dca_cb[0] vccdig vssx ringpll__pll_inbuf_ln
Xi210[2] fz_lockcnt_i[2] fz_lockcnt[2] vccdig vssx ringpll__pll_inbuf_ln
Xi210[1] fz_lockcnt_i[1] fz_lockcnt[1] vccdig vssx ringpll__pll_inbuf_ln
Xi210[0] fz_lockcnt_i[0] fz_lockcnt[0] vccdig vssx ringpll__pll_inbuf_ln
Xi207[3] fz_lockthresh_i[3] fz_lockthresh[3] vccdig vssx ringpll__pll_inbuf_ln
Xi207[2] fz_lockthresh_i[2] fz_lockthresh[2] vccdig vssx ringpll__pll_inbuf_ln
Xi207[1] fz_lockthresh_i[1] fz_lockthresh[1] vccdig vssx ringpll__pll_inbuf_ln
Xi207[0] fz_lockthresh_i[0] fz_lockthresh[0] vccdig vssx ringpll__pll_inbuf_ln
Xi209 fz_lockforce_i fz_lockforce vccdig vssx ringpll__pll_inbuf_ln
Xi211[4] fz_irefgen_i[4] fz_irefgen[4] vccdig vssx ringpll__pll_inbuf_ln
Xi211[3] fz_irefgen_i[3] fz_irefgen[3] vccdig vssx ringpll__pll_inbuf_ln
Xi211[2] fz_irefgen_i[2] fz_irefgen[2] vccdig vssx ringpll__pll_inbuf_ln
Xi211[1] fz_irefgen_i[1] fz_irefgen[1] vccdig vssx ringpll__pll_inbuf_ln
Xi211[0] fz_irefgen_i[0] fz_irefgen[0] vccdig vssx ringpll__pll_inbuf_ln
Xi206[2] fz_pfd_pw_i[2] fz_pfd_pw[2] vccdig vssx ringpll__pll_inbuf_ln
Xi206[1] fz_pfd_pw_i[1] fz_pfd_pw[1] vccdig vssx ringpll__pll_inbuf_ln
Xi206[0] fz_pfd_pw_i[0] fz_pfd_pw[0] vccdig vssx ringpll__pll_inbuf_ln
Xi203[1] fz_pfddly_i[1] fz_pfddly[1] vccdig vssx ringpll__pll_inbuf_ln
Xi203[0] fz_pfddly_i[0] fz_pfddly[0] vccdig vssx ringpll__pll_inbuf_ln
Xi199[5] fz_startup_i[5] fz_startup[5] vccdig vssx ringpll__pll_inbuf_ln
Xi199[4] fz_startup_i[4] fz_startup[4] vccdig vssx ringpll__pll_inbuf_ln
Xi199[3] fz_startup_i[3] fz_startup[3] vccdig vssx ringpll__pll_inbuf_ln
Xi199[2] fz_startup_i[2] fz_startup[2] vccdig vssx ringpll__pll_inbuf_ln
Xi199[1] fz_startup_i[1] fz_startup[1] vccdig vssx ringpll__pll_inbuf_ln
Xi199[0] fz_startup_i[0] fz_startup[0] vccdig vssx ringpll__pll_inbuf_ln
Xi205[4] fz_spare_i[4] fz_spare[4] vccdig vssx ringpll__pll_inbuf_ln
Xi205[3] fz_spare_i[3] fz_spare[3] vccdig vssx ringpll__pll_inbuf_ln
Xi205[2] fz_spare_i[2] fz_spare[2] vccdig vssx ringpll__pll_inbuf_ln
Xi205[1] fz_spare_i[1] fz_spare[1] vccdig vssx ringpll__pll_inbuf_ln
Xi205[0] fz_spare_i[0] fz_spare[0] vccdig vssx ringpll__pll_inbuf_ln
Xi204[4] fz_skadj_i[4] fz_skadj[4] vccdig vssx ringpll__pll_inbuf_ln
Xi204[3] fz_skadj_i[3] fz_skadj[3] vccdig vssx ringpll__pll_inbuf_ln
Xi204[2] fz_skadj_i[2] fz_skadj[2] vccdig vssx ringpll__pll_inbuf_ln
Xi204[1] fz_skadj_i[1] fz_skadj[1] vccdig vssx ringpll__pll_inbuf_ln
Xi204[0] fz_skadj_i[0] fz_skadj[0] vccdig vssx ringpll__pll_inbuf_ln
Xi202 fz_lpfclksel_i fz_lpfclksel vccdig vssx ringpll__pll_inbuf_ln
Xi201 fz_nopfdpwrgate_i fz_nopfdpwrgate vccdig vssx ringpll__pll_inbuf_ln
Xi200 fz_lockstickyb_i fz_lockstickyb vccdig vssx ringpll__pll_inbuf_ln
Xi198[10] fz_vcotrim_i[10] fz_vcotrim[10] vccdig vssx ringpll__pll_inbuf_ln
Xi198[9] fz_vcotrim_i[9] fz_vcotrim[9] vccdig vssx ringpll__pll_inbuf_ln
Xi198[8] fz_vcotrim_i[8] fz_vcotrim[8] vccdig vssx ringpll__pll_inbuf_ln
Xi198[7] fz_vcotrim_i[7] fz_vcotrim[7] vccdig vssx ringpll__pll_inbuf_ln
Xi198[6] fz_vcotrim_i[6] fz_vcotrim[6] vccdig vssx ringpll__pll_inbuf_ln
Xi198[5] fz_vcotrim_i[5] fz_vcotrim[5] vccdig vssx ringpll__pll_inbuf_ln
Xi198[4] fz_vcotrim_i[4] fz_vcotrim[4] vccdig vssx ringpll__pll_inbuf_ln
Xi198[3] fz_vcotrim_i[3] fz_vcotrim[3] vccdig vssx ringpll__pll_inbuf_ln
Xi198[2] fz_vcotrim_i[2] fz_vcotrim[2] vccdig vssx ringpll__pll_inbuf_ln
Xi198[1] fz_vcotrim_i[1] fz_vcotrim[1] vccdig vssx ringpll__pll_inbuf_ln
Xi198[0] fz_vcotrim_i[0] fz_vcotrim[0] vccdig vssx ringpll__pll_inbuf_ln
Xi197 fz_vcosel_i fz_vcosel vccdig vssx ringpll__pll_inbuf_ln
Xi196 idvfreqai_i idvfreqai vccdig vssx ringpll__pll_inbuf_ln
Xi195 idvfreqbi_i idvfreqbi vccdig vssx ringpll__pll_inbuf_ln
Xi194 idvpulsei_i idvpulsei vccdig vssx ringpll__pll_inbuf_ln
Xi193 idvdisable_bi_i idvdisable_bi vccdig vssx ringpll__pll_inbuf_ln
Xi192 fz_tight_loopb_i fz_tight_loopb vccdig vssx ringpll__pll_inbuf_ln
Xi212[1] fz_cpnbias_i[1] fz_cpnbias[1] vccdig vssx ringpll__pll_inbuf_ln
Xi212[0] fz_cpnbias_i[0] fz_cpnbias[0] vccdig vssx ringpll__pll_inbuf_ln
Xi190 ssc_en_i ssc_en vccdig vssx ringpll__pll_inbuf_ln
Xi187[9] zdiv1_ratio_i[9] zdiv1_ratio[9] vccdig vssx ringpll__pll_inbuf_ln
Xi187[8] zdiv1_ratio_i[8] zdiv1_ratio[8] vccdig vssx ringpll__pll_inbuf_ln
Xi187[7] zdiv1_ratio_i[7] zdiv1_ratio[7] vccdig vssx ringpll__pll_inbuf_ln
Xi187[6] zdiv1_ratio_i[6] zdiv1_ratio[6] vccdig vssx ringpll__pll_inbuf_ln
Xi187[5] zdiv1_ratio_i[5] zdiv1_ratio[5] vccdig vssx ringpll__pll_inbuf_ln
Xi187[4] zdiv1_ratio_i[4] zdiv1_ratio[4] vccdig vssx ringpll__pll_inbuf_ln
Xi187[3] zdiv1_ratio_i[3] zdiv1_ratio[3] vccdig vssx ringpll__pll_inbuf_ln
Xi187[2] zdiv1_ratio_i[2] zdiv1_ratio[2] vccdig vssx ringpll__pll_inbuf_ln
Xi187[1] zdiv1_ratio_i[1] zdiv1_ratio[1] vccdig vssx ringpll__pll_inbuf_ln
Xi187[0] zdiv1_ratio_i[0] zdiv1_ratio[0] vccdig vssx ringpll__pll_inbuf_ln
Xi188 zdiv1_ratio_p5_i zdiv1_ratio_p5 vccdig vssx ringpll__pll_inbuf_ln
Xi214[4] fz_cp1trim_i[4] fz_cp1trim[4] vccdig vssx ringpll__pll_inbuf_ln
Xi214[3] fz_cp1trim_i[3] fz_cp1trim[3] vccdig vssx ringpll__pll_inbuf_ln
Xi214[2] fz_cp1trim_i[2] fz_cp1trim[2] vccdig vssx ringpll__pll_inbuf_ln
Xi214[1] fz_cp1trim_i[1] fz_cp1trim[1] vccdig vssx ringpll__pll_inbuf_ln
Xi214[0] fz_cp1trim_i[0] fz_cp1trim[0] vccdig vssx ringpll__pll_inbuf_ln
Xi186 zdiv0_ratio_p5_i zdiv0_ratio_p5 vccdig vssx ringpll__pll_inbuf_ln
Xi184[1] vcodiv_ratio_i[1] vcodiv_ratio[1] vccdig vssx ringpll__pll_inbuf_ln
Xi184[0] vcodiv_ratio_i[0] vcodiv_ratio[0] vccdig vssx ringpll__pll_inbuf_ln
Xi189[9] zdiv0_ratio_i[9] zdiv0_ratio[9] vccdig vssx ringpll__pll_inbuf_ln
Xi189[8] zdiv0_ratio_i[8] zdiv0_ratio[8] vccdig vssx ringpll__pll_inbuf_ln
Xi189[7] zdiv0_ratio_i[7] zdiv0_ratio[7] vccdig vssx ringpll__pll_inbuf_ln
Xi189[6] zdiv0_ratio_i[6] zdiv0_ratio[6] vccdig vssx ringpll__pll_inbuf_ln
Xi189[5] zdiv0_ratio_i[5] zdiv0_ratio[5] vccdig vssx ringpll__pll_inbuf_ln
Xi189[4] zdiv0_ratio_i[4] zdiv0_ratio[4] vccdig vssx ringpll__pll_inbuf_ln
Xi189[3] zdiv0_ratio_i[3] zdiv0_ratio[3] vccdig vssx ringpll__pll_inbuf_ln
Xi189[2] zdiv0_ratio_i[2] zdiv0_ratio[2] vccdig vssx ringpll__pll_inbuf_ln
Xi189[1] zdiv0_ratio_i[1] zdiv0_ratio[1] vccdig vssx ringpll__pll_inbuf_ln
Xi189[0] zdiv0_ratio_i[0] zdiv0_ratio[0] vccdig vssx ringpll__pll_inbuf_ln
Xi185[23] ssc_frac_step_i[23] ssc_frac_step[23] vccdig vssx ringpll__pll_inbuf_ln
Xi185[22] ssc_frac_step_i[22] ssc_frac_step[22] vccdig vssx ringpll__pll_inbuf_ln
Xi185[21] ssc_frac_step_i[21] ssc_frac_step[21] vccdig vssx ringpll__pll_inbuf_ln
Xi185[20] ssc_frac_step_i[20] ssc_frac_step[20] vccdig vssx ringpll__pll_inbuf_ln
Xi185[19] ssc_frac_step_i[19] ssc_frac_step[19] vccdig vssx ringpll__pll_inbuf_ln
Xi185[18] ssc_frac_step_i[18] ssc_frac_step[18] vccdig vssx ringpll__pll_inbuf_ln
Xi185[17] ssc_frac_step_i[17] ssc_frac_step[17] vccdig vssx ringpll__pll_inbuf_ln
Xi185[16] ssc_frac_step_i[16] ssc_frac_step[16] vccdig vssx ringpll__pll_inbuf_ln
Xi185[15] ssc_frac_step_i[15] ssc_frac_step[15] vccdig vssx ringpll__pll_inbuf_ln
Xi185[14] ssc_frac_step_i[14] ssc_frac_step[14] vccdig vssx ringpll__pll_inbuf_ln
Xi185[13] ssc_frac_step_i[13] ssc_frac_step[13] vccdig vssx ringpll__pll_inbuf_ln
Xi185[12] ssc_frac_step_i[12] ssc_frac_step[12] vccdig vssx ringpll__pll_inbuf_ln
Xi185[11] ssc_frac_step_i[11] ssc_frac_step[11] vccdig vssx ringpll__pll_inbuf_ln
Xi185[10] ssc_frac_step_i[10] ssc_frac_step[10] vccdig vssx ringpll__pll_inbuf_ln
Xi185[9] ssc_frac_step_i[9] ssc_frac_step[9] vccdig vssx ringpll__pll_inbuf_ln
Xi185[8] ssc_frac_step_i[8] ssc_frac_step[8] vccdig vssx ringpll__pll_inbuf_ln
Xi185[7] ssc_frac_step_i[7] ssc_frac_step[7] vccdig vssx ringpll__pll_inbuf_ln
Xi185[6] ssc_frac_step_i[6] ssc_frac_step[6] vccdig vssx ringpll__pll_inbuf_ln
Xi185[5] ssc_frac_step_i[5] ssc_frac_step[5] vccdig vssx ringpll__pll_inbuf_ln
Xi185[4] ssc_frac_step_i[4] ssc_frac_step[4] vccdig vssx ringpll__pll_inbuf_ln
Xi185[3] ssc_frac_step_i[3] ssc_frac_step[3] vccdig vssx ringpll__pll_inbuf_ln
Xi185[2] ssc_frac_step_i[2] ssc_frac_step[2] vccdig vssx ringpll__pll_inbuf_ln
Xi185[1] ssc_frac_step_i[1] ssc_frac_step[1] vccdig vssx ringpll__pll_inbuf_ln
Xi185[0] ssc_frac_step_i[0] ssc_frac_step[0] vccdig vssx ringpll__pll_inbuf_ln
Xi181 pllfwen_b_i pllfwen_b vccdig vssx ringpll__pll_inbuf_ln
Xi180 pllen_i pllen vccdig vssx ringpll__pll_inbuf_ln
Xi178[5] mdiv_ratio_i[5] mdiv_ratio[5] vccdig vssx ringpll__pll_inbuf_ln
Xi178[4] mdiv_ratio_i[4] mdiv_ratio[4] vccdig vssx ringpll__pll_inbuf_ln
Xi178[3] mdiv_ratio_i[3] mdiv_ratio[3] vccdig vssx ringpll__pll_inbuf_ln
Xi178[2] mdiv_ratio_i[2] mdiv_ratio[2] vccdig vssx ringpll__pll_inbuf_ln
Xi178[1] mdiv_ratio_i[1] mdiv_ratio[1] vccdig vssx ringpll__pll_inbuf_ln
Xi178[0] mdiv_ratio_i[0] mdiv_ratio[0] vccdig vssx ringpll__pll_inbuf_ln
Xi183[8] ssc_cyc_to_peak_m1_i[8] ssc_cyc_to_peak_m1[8] vccdig vssx ringpll__pll_inbuf_ln
Xi183[7] ssc_cyc_to_peak_m1_i[7] ssc_cyc_to_peak_m1[7] vccdig vssx ringpll__pll_inbuf_ln
Xi183[6] ssc_cyc_to_peak_m1_i[6] ssc_cyc_to_peak_m1[6] vccdig vssx ringpll__pll_inbuf_ln
Xi183[5] ssc_cyc_to_peak_m1_i[5] ssc_cyc_to_peak_m1[5] vccdig vssx ringpll__pll_inbuf_ln
Xi183[4] ssc_cyc_to_peak_m1_i[4] ssc_cyc_to_peak_m1[4] vccdig vssx ringpll__pll_inbuf_ln
Xi183[3] ssc_cyc_to_peak_m1_i[3] ssc_cyc_to_peak_m1[3] vccdig vssx ringpll__pll_inbuf_ln
Xi183[2] ssc_cyc_to_peak_m1_i[2] ssc_cyc_to_peak_m1[2] vccdig vssx ringpll__pll_inbuf_ln
Xi183[1] ssc_cyc_to_peak_m1_i[1] ssc_cyc_to_peak_m1[1] vccdig vssx ringpll__pll_inbuf_ln
Xi183[0] ssc_cyc_to_peak_m1_i[0] ssc_cyc_to_peak_m1[0] vccdig vssx ringpll__pll_inbuf_ln
Xi177 mash_order_plus_one_i mash_order_plus_one vccdig vssx ringpll__pll_inbuf_ln
Xi179[23] fraction_i[23] fraction[23] vccdig vssx ringpll__pll_inbuf_ln
Xi179[22] fraction_i[22] fraction[22] vccdig vssx ringpll__pll_inbuf_ln
Xi179[21] fraction_i[21] fraction[21] vccdig vssx ringpll__pll_inbuf_ln
Xi179[20] fraction_i[20] fraction[20] vccdig vssx ringpll__pll_inbuf_ln
Xi179[19] fraction_i[19] fraction[19] vccdig vssx ringpll__pll_inbuf_ln
Xi179[18] fraction_i[18] fraction[18] vccdig vssx ringpll__pll_inbuf_ln
Xi179[17] fraction_i[17] fraction[17] vccdig vssx ringpll__pll_inbuf_ln
Xi179[16] fraction_i[16] fraction[16] vccdig vssx ringpll__pll_inbuf_ln
Xi179[15] fraction_i[15] fraction[15] vccdig vssx ringpll__pll_inbuf_ln
Xi179[14] fraction_i[14] fraction[14] vccdig vssx ringpll__pll_inbuf_ln
Xi179[13] fraction_i[13] fraction[13] vccdig vssx ringpll__pll_inbuf_ln
Xi179[12] fraction_i[12] fraction[12] vccdig vssx ringpll__pll_inbuf_ln
Xi179[11] fraction_i[11] fraction[11] vccdig vssx ringpll__pll_inbuf_ln
Xi179[10] fraction_i[10] fraction[10] vccdig vssx ringpll__pll_inbuf_ln
Xi179[9] fraction_i[9] fraction[9] vccdig vssx ringpll__pll_inbuf_ln
Xi179[8] fraction_i[8] fraction[8] vccdig vssx ringpll__pll_inbuf_ln
Xi179[7] fraction_i[7] fraction[7] vccdig vssx ringpll__pll_inbuf_ln
Xi179[6] fraction_i[6] fraction[6] vccdig vssx ringpll__pll_inbuf_ln
Xi179[5] fraction_i[5] fraction[5] vccdig vssx ringpll__pll_inbuf_ln
Xi179[4] fraction_i[4] fraction[4] vccdig vssx ringpll__pll_inbuf_ln
Xi179[3] fraction_i[3] fraction[3] vccdig vssx ringpll__pll_inbuf_ln
Xi179[2] fraction_i[2] fraction[2] vccdig vssx ringpll__pll_inbuf_ln
Xi179[1] fraction_i[1] fraction[1] vccdig vssx ringpll__pll_inbuf_ln
Xi179[0] fraction_i[0] fraction[0] vccdig vssx ringpll__pll_inbuf_ln
Xi175 bypass_i bypass vccdig vssx ringpll__pll_inbuf_ln
Xi174 fz_ldo_faststart_i fz_ldo_faststart vccdig vssx ringpll__pll_inbuf_ln
Xi176[9] ratio_i[9] ratio[9] vccdig vssx ringpll__pll_inbuf_ln
Xi176[8] ratio_i[8] ratio[8] vccdig vssx ringpll__pll_inbuf_ln
Xi176[7] ratio_i[7] ratio[7] vccdig vssx ringpll__pll_inbuf_ln
Xi176[6] ratio_i[6] ratio[6] vccdig vssx ringpll__pll_inbuf_ln
Xi176[5] ratio_i[5] ratio[5] vccdig vssx ringpll__pll_inbuf_ln
Xi176[4] ratio_i[4] ratio[4] vccdig vssx ringpll__pll_inbuf_ln
Xi176[3] ratio_i[3] ratio[3] vccdig vssx ringpll__pll_inbuf_ln
Xi176[2] ratio_i[2] ratio[2] vccdig vssx ringpll__pll_inbuf_ln
Xi176[1] ratio_i[1] ratio[1] vccdig vssx ringpll__pll_inbuf_ln
Xi176[0] ratio_i[0] ratio[0] vccdig vssx ringpll__pll_inbuf_ln
Xi172[3] fz_ldo_reftrim_i[3] fz_ldo_reftrim[3] vccdig vssx ringpll__pll_inbuf_ln
Xi172[2] fz_ldo_reftrim_i[2] fz_ldo_reftrim[2] vccdig vssx ringpll__pll_inbuf_ln
Xi172[1] fz_ldo_reftrim_i[1] fz_ldo_reftrim[1] vccdig vssx ringpll__pll_inbuf_ln
Xi172[0] fz_ldo_reftrim_i[0] fz_ldo_reftrim[0] vccdig vssx ringpll__pll_inbuf_ln
Xi170 fz_ldo_bypass_i fz_ldo_bypass vccdig vssx ringpll__pll_inbuf_ln
Xi169 fz_ldo_extrefsel_i fz_ldo_extrefsel vccdig vssx ringpll__pll_inbuf_ln
Xi171[3] fz_ldo_fbtrim_i[3] fz_ldo_fbtrim[3] vccdig vssx ringpll__pll_inbuf_ln
Xi171[2] fz_ldo_fbtrim_i[2] fz_ldo_fbtrim[2] vccdig vssx ringpll__pll_inbuf_ln
Xi171[1] fz_ldo_fbtrim_i[1] fz_ldo_fbtrim[1] vccdig vssx ringpll__pll_inbuf_ln
Xi171[0] fz_ldo_fbtrim_i[0] fz_ldo_fbtrim[0] vccdig vssx ringpll__pll_inbuf_ln
Xi216 tshiftdr_i tshiftdr vccdig vssx ringpll__pll_inbuf_ln
Xipgdbuf powergood_vnn_buf powergood_vnn vnnaon vssx ringpll__pll_inbuf_ln
Xi259[2] idfx_fscan_sdi_i[2] idfx_fscan_sdi[2] vccdig vssx ringpll__pll_inbuf_ln
Xi259[1] idfx_fscan_sdi_i[1] idfx_fscan_sdi[1] vccdig vssx ringpll__pll_inbuf_ln
Xi259[0] idfx_fscan_sdi_i[0] idfx_fscan_sdi[0] vccdig vssx ringpll__pll_inbuf_ln
Xi258 idfx_fscan_mode_i idfx_fscan_mode vccdig vssx ringpll__pll_inbuf_ln
Xi257 idfx_fscan_shiften_i idfx_fscan_shiften vccdig vssx ringpll__pll_inbuf_ln
Xi256 idfx_fscan_rstbypen_i idfx_fscan_rstbypen vccdig vssx ringpll__pll_inbuf_ln
Xi255 idfx_fscan_byprstb_i idfx_fscan_byprstb vccdig vssx ringpll__pll_inbuf_ln
Xi254 idfx_fscan_clkungate_i idfx_fscan_clkungate vccdig vssx ringpll__pll_inbuf_ln
Xi167 ldo_enable_i ldo_enable vccdig vssx ringpll__pll_inbuf_ln
Xi225 idvtclki_i idvtclki vccdig vssx ringpll__pll_inbuf_ln
Xi224 idvtctrli_i idvtctrli vccdig vssx ringpll__pll_inbuf_ln
Xi223 idvtdi_i idvtdi vccdig vssx ringpll__pll_inbuf_ln
Xi222 idvtresi_i idvtresi vccdig vssx ringpll__pll_inbuf_ln
Xi221 tck_i tck vccdig vssx ringpll__pll_inbuf_ln
Xi220 tcapturedr_i tcapturedr vccdig vssx ringpll__pll_inbuf_ln
Xi219 tdi_i tdi vccdig vssx ringpll__pll_inbuf_ln
Xi218 treg_en_i treg_en vccdig vssx ringpll__pll_inbuf_ln
Xi168[1] fz_ldo_vinvoltsel_i[1] fz_ldo_vinvoltsel[1] vccdig vssx ringpll__pll_inbuf_ln
Xi168[0] fz_ldo_vinvoltsel_i[0] fz_ldo_vinvoltsel[0] vccdig vssx ringpll__pll_inbuf_ln
Xi217 trst_n_i trst_n vccdig vssx ringpll__pll_inbuf_ln
Xi215 tupdatedr_i tupdatedr vccdig vssx ringpll__pll_inbuf_ln
Xsg000 powergood_vnn powergood_vccdig vnnaon vccdig vssx ringpll__b15sg00ndal1d04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ssc_mod_dfx
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ssc_mod_dfx dm_sync_reset_clkgen__clkfbgatemxh lockxxnnnl dfx__sscmodtrignh dfx__sscmodstepsnh[1] dfx__sscmodstepsnh[0] dfx__sscdfxennh dfx__sscmodclkdivnh[1] dfx__sscmodclkdivnh[0] ssc_mod_dfx__triggerregxdh ssc_mod_dfx__modulatorennh ssc_mod_dfx__clkmodmxh vdd vssx p3 p39 p_abuf0 p_abuf1 p_abuf2
* .PININFO dfx__sscdfxennh:I dfx__sscmodclkdivnh[1]:I dfx__sscmodclkdivnh[0]:I dfx__sscmodstepsnh[1]:I dfx__sscmodstepsnh[0]:I dfx__sscmodtrignh:I
* .PININFO dm_sync_reset_clkgen__clkfbgatemxh:I lockxxnnnl:I p3:I p39:I vdd:I vssx:I p_abuf0:O p_abuf1:O p_abuf2:O ssc_mod_dfx__clkmodmxh:O
* .PININFO ssc_mod_dfx__modulatorennh:O ssc_mod_dfx__triggerregxdh:O
Xctech_lib_doublesync_rstbtaptriggerxd0h_rccu1 clkmoddfxxdh dfx__sscmodtrignh taptriggerxd0h net282 p3 p39 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xu26 n17 dfx__sscmodstepsnh[1] dfx__sscmodstepsnh[0] n20 vdd vssx ringpll__b15nand03al1n03x5 m=1
Xu14 taptriggerxd0h n2 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu10 divcntmxl[0] divcntnxtmxl[0] vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu3 dm_sync_reset_clkgen__clkfbgatemxh clkfbmxh_b vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu24 n17 n8 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu19 countxdh[5] n4 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu18 countxdh[4] n23 n16 vdd vssx ringpll__b15nor002al1n03x5 m=1
Xu20 n17 dfx__sscmodstepsnh[1] n3 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu25 n8 ssc_mod_dfx__modulatorennh n21 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu22 n4 n16 ssc_mod_dfx__modulatorennh vdd vssx ringpll__b15nand02al1n03x5 m=1
Xcts_cts_buf_5081206 p_abuf2 ssc_mod_dfx__clkmodmxh vdd vssx ringpll__b15cbf000ah1n48x5 m=1
Xcts_cts_buf_5051203 ssc_mod_dfx__clkmodmxh p_abuf0 vdd vssx ringpll__b15cbf000ah1n48x5 m=1
Xcts_cts_buf_5061204 ssc_mod_dfx__clkmodmxh p_abuf1 vdd vssx ringpll__b15cbf000ah1n64x5 m=1
Xu6 clkdiv4mxh divcntmxl[2] clkdiv8mxh vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu5 clkdiv2mxh divcntmxl[1] clkdiv4mxh vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu28 countxdh[0] countxdh[1] n6 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu4 divcntmxl[0] clkfbmxh_b clkdiv2mxh vdd vssx ringpll__b15norp02al1n03x5 m=1
Xcts_cts_dlydt_1669 cts0 cts6 vdd vssx ringpll__b15cbf000ah1n02x5 m=1
Xcts_cts_dlydt_1660 clkfbmxh_b cts0 vdd vssx ringpll__b15cbf000ah1n02x5 m=1
Xu11 divcntmxl[1] divcntmxl[0] divcntmxl[1] divcntnxtmxl[0] divcntnxtmxl[1] vdd vssx ringpll__b15aboi22al1n02x3 m=1
Xu39 n19 countxdh[3] n22 vdd vssx ringpll__b15nanb02al1n02x5 m=1
Xu17 countxdh[3] n19 n23 vdd vssx ringpll__b15nanb02al1n02x5 m=1
Xu16 countxdh[0] countxdh[1] countxdh[2] n19 vdd vssx ringpll__b15nor003al1n02x5 m=1
Xu9 net282 dfx__sscmodclkdivnh[1] sscmodclkdivqualnh[1] vdd vssx ringpll__b15and002an1n03x5 m=1
Xu8 net282 dfx__sscmodclkdivnh[0] sscmodclkdivqualnh[0] vdd vssx ringpll__b15and002al1n04x5 m=1
Xu27 n20 n5 n21 n11 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu30 n20 n7 n21 n10 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu12 divcntmxl[2] divcntmxl[1] divcntmxl[0] n1 vdd vssx ringpll__b15oai012al1n02x5 m=1
Xu21 n3 n17 n16 n4 n14 vdd vssx ringpll__b15oai013al1n02x3 m=1
Xu13 n1 divcntmxl[1] divcntmxl[2] divcntmxl[0] divcntnxtmxl[2] vdd vssx ringpll__b15oai013al1n02x3 m=1
Xu15 ssc_mod_dfx__triggerregxdh taptriggerxd0h ssc_mod_dfx__triggerregxdh n2 n17 vdd vssx ringpll__b15obai22an1n02x5 m=1
Xcountxdh_reg[2] clkmoddfxxdh n11 countxdh[2] net282 vdd vssx ringpll__b15fqn003al1n02x5 m=1
Xcountxdh_reg[0] clkmoddfxxdh n15 countxdh[0] net282 vdd vssx ringpll__b15fqn003al1n02x5 m=1
Xcountxdh_reg[3] clkmoddfxxdh n12 countxdh[3] net282 vdd vssx ringpll__b15fqn003al1n02x5 m=1
Xcountxdh_reg[4] clkmoddfxxdh n13 countxdh[4] net282 vdd vssx ringpll__b15fqn003al1n02x5 m=1
Xcountxdh_reg[5] clkmoddfxxdh n14 countxdh[5] net282 vdd vssx ringpll__b15fqn003al1n02x5 m=1
Xcountxdh_reg[1] clkmoddfxxdh n10 countxdh[1] net282 vdd vssx ringpll__b15fqn003al1n02x5 m=1
Xtaptriggerxd1h_reg clkmoddfxxdh taptriggerxd0h ssc_mod_dfx__triggerregxdh net282 vdd vssx ringpll__b15fqn003al1n02x5 m=1
Xu33 n16 countxdh[4] n23 n18 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu29 n6 countxdh[1] countxdh[0] n7 vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu34 dfx__sscmodstepsnh[0] n17 n18 n21 n13 vdd vssx ringpll__b15naoai3el1n02x5 m=1
Xu31 dfx__sscmodstepsnh[1] dfx__sscmodstepsnh[0] n8 n9 vdd vssx ringpll__b15orn003al1n02x5 m=1
Xu32 n20 n9 countxdh[0] n21 n15 vdd vssx ringpll__b15oai112al1n02x5 m=1
Xu267 net282 net34 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu822 net34 net256 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu841 net256 net275 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu842 net351 net276 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu843 net276 net277 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu917 net275 net351 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1009 net282 net443 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu914 net443 net348 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu271 net348 net38 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu879 net258 net313 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1078 net313 net512 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu824 net38 net258 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu849 ctech_lib_doublesync_rstbtaptriggerxd0h_rstb net283 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu848 net283 net282 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu916 net338 net350 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu904 net444 net338 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu270 net311 net37 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu877 net257 net311 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu823 net282 net257 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1010 net37 net444 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xdivcntmxl_reg[0] cts6 divcntnxtmxl[0] divcntmxl[0] net512 vdd vssx ringpll__b15fqn00cal1n02x3 m=1
Xdivcntmxl_reg[1] cts6 divcntnxtmxl[1] divcntmxl[1] net350 vdd vssx ringpll__b15fqn00cal1n02x3 m=1
Xu7 dfx__sscdfxennh lockxxnnnl ctech_lib_doublesync_rstbtaptriggerxd0h_rstb vdd vssx ringpll__b15and002ah1n04x5 m=1
Xdivcntmxl_reg[2] cts6 divcntnxtmxl[2] divcntmxl[2] net277 vdd vssx ringpll__b15fqn00cal1n04x3 m=1
Xu23 n19 countxdh[2] countxdh[0] countxdh[1] n5 vdd vssx ringpll__b15oaoi13al1n02x3 m=1
Xu40 n20 n21 n23 n22 n12 vdd vssx ringpll__b15aoai13al1n02x3 m=1
Xu38 dfxmodenxdl p_abuf3 p_abuf2 vdd vssx ringpll__b15and002ah1n24x5 m=1
Xu35 ssc_mod_dfx__modulatorennh net282 n26 vdd vssx ringpll__b15nanb02an1n02x5 m=1
Xdfxmodenxdl_reg clkmoddfxxdh n26 dfxmodenxdl vdd vssx ringpll__b15lsn080al1n02x3 m=1
Xclk2to1mux_clkmoddfx1xdh clkmoddfx1xdh clkdiv4mxh clkdiv8mxh sscmodclkdivqualnh[0] vdd vssx ringpll__clk2to1mux_1
Xclk2to1mux_clkmoddfxxdh clkmoddfxxdh clkmoddfx0xdh clkmoddfx1xdh sscmodclkdivqualnh[1] vdd vssx p_abuf3 ringpll__clk2to1mux_0
Xclk2to1mux_clkmoddfx0xdh clkmoddfx0xdh cts0 clkdiv2mxh sscmodclkdivqualnh[0] vdd vssx ringpll__clk2to1mux_2
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    mash_mod
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__mash_mod ssc_mod_dfx__clkmodmxh lockxxnnnl reg_req_ack__mashstateresetmxh dfx__mash_order_plus_one ratio_async_mux__ratiomxh[9] ratio_async_mux__ratiomxh[8] ratio_async_mux__ratiomxh[7] ratio_async_mux__ratiomxh[6] ratio_async_mux__ratiomxh[5] ratio_async_mux__ratiomxh[4] ratio_async_mux__ratiomxh[3] ratio_async_mux__ratiomxh[2] ratio_async_mux__ratiomxh[1] ratio_async_mux__ratiomxh[0] ratio_async_mux__fractionmxh[23] ratio_async_mux__fractionmxh[22] ratio_async_mux__fractionmxh[21] ratio_async_mux__fractionmxh[20] ratio_async_mux__fractionmxh[19] ratio_async_mux__fractionmxh[18] ratio_async_mux__fractionmxh[17] ratio_async_mux__fractionmxh[16] ratio_async_mux__fractionmxh[15] ratio_async_mux__fractionmxh[14] ratio_async_mux__fractionmxh[13] ratio_async_mux__fractionmxh[12] ratio_async_mux__fractionmxh[11] ratio_async_mux__fractionmxh[10] ratio_async_mux__fractionmxh[9] ratio_async_mux__fractionmxh[8] ratio_async_mux__fractionmxh[7] ratio_async_mux__fractionmxh[6] ratio_async_mux__fractionmxh[5] ratio_async_mux__fractionmxh[4] ratio_async_mux__fractionmxh[3] ratio_async_mux__fractionmxh[2] ratio_async_mux__fractionmxh[1] ratio_async_mux__fractionmxh[0] mash__ratiomxh[9] mash__ratiomxh[8] mash__ratiomxh[7] mash__ratiomxh[6] mash__ratiomxh[5] mash__ratiomxh[4] mash__ratiomxh[3] mash__ratiomxh[2] mash__ratiomxh[1] mash__ratiomxh[0] mash__halfintmxh mash__pllmodonnh vdd vssx p_abuf0 p_abuf1 p_abuf2 p_abuf3 p_abuf4 p_abuf5 p_abuf6 p_abuf7 p_abuf8 p_abuf9 p_abuf10 p_abuf11 p_abuf12 p_abuf13 p_abuf14 p_abuf15 p61
* .PININFO dfx__mash_order_plus_one:I lockxxnnnl:I p61:I p_abuf0:I p_abuf1:I p_abuf2:I p_abuf3:I p_abuf4:I p_abuf5:I p_abuf6:I p_abuf7:I p_abuf8:I
* .PININFO p_abuf9:I p_abuf10:I p_abuf11:I p_abuf12:I p_abuf13:I p_abuf14:I p_abuf15:I ratio_async_mux__fractionmxh[23]:I
* .PININFO ratio_async_mux__fractionmxh[22]:I ratio_async_mux__fractionmxh[21]:I ratio_async_mux__fractionmxh[20]:I ratio_async_mux__fractionmxh[19]:I
* .PININFO ratio_async_mux__fractionmxh[18]:I ratio_async_mux__fractionmxh[17]:I ratio_async_mux__fractionmxh[16]:I ratio_async_mux__fractionmxh[15]:I
* .PININFO ratio_async_mux__fractionmxh[14]:I ratio_async_mux__fractionmxh[13]:I ratio_async_mux__fractionmxh[12]:I ratio_async_mux__fractionmxh[11]:I
* .PININFO ratio_async_mux__fractionmxh[10]:I ratio_async_mux__fractionmxh[9]:I ratio_async_mux__fractionmxh[8]:I ratio_async_mux__fractionmxh[7]:I
* .PININFO ratio_async_mux__fractionmxh[6]:I ratio_async_mux__fractionmxh[5]:I ratio_async_mux__fractionmxh[4]:I ratio_async_mux__fractionmxh[3]:I
* .PININFO ratio_async_mux__fractionmxh[2]:I ratio_async_mux__fractionmxh[1]:I ratio_async_mux__fractionmxh[0]:I ratio_async_mux__ratiomxh[9]:I
* .PININFO ratio_async_mux__ratiomxh[8]:I ratio_async_mux__ratiomxh[7]:I ratio_async_mux__ratiomxh[6]:I ratio_async_mux__ratiomxh[5]:I
* .PININFO ratio_async_mux__ratiomxh[4]:I ratio_async_mux__ratiomxh[3]:I ratio_async_mux__ratiomxh[2]:I ratio_async_mux__ratiomxh[1]:I
* .PININFO ratio_async_mux__ratiomxh[0]:I reg_req_ack__mashstateresetmxh:I ssc_mod_dfx__clkmodmxh:I vdd:I vssx:I mash__halfintmxh:O mash__pllmodonnh:O
* .PININFO mash__ratiomxh[9]:O mash__ratiomxh[8]:O mash__ratiomxh[7]:O mash__ratiomxh[6]:O mash__ratiomxh[5]:O mash__ratiomxh[4]:O mash__ratiomxh[3]:O
* .PININFO mash__ratiomxh[2]:O mash__ratiomxh[1]:O mash__ratiomxh[0]:O
Xu15 n7 deltanmxh[0] ratio_async_mux__fractionmxh[23] mash__halfintmxh vdd vssx ringpll__b15oab012ah1n02x5 m=1
Xu5 deltanmxh[0] ratio_async_mux__fractionmxh[23] n7 vdd vssx ringpll__b15and002an1n03x5 m=1
Xu42 deltanmxh_10 n12 vdd vssx ringpll__b15bfn001an1n06x5 m=1
Xu38 errvalmxh[42] dfx__mash_order_plus_one fractionlastordermxh[19] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu34 errvalmxh[38] dfx__mash_order_plus_one fractionlastordermxh[15] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu32 errvalmxh[36] dfx__mash_order_plus_one fractionlastordermxh[13] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu31 errvalmxh[35] dfx__mash_order_plus_one fractionlastordermxh[12] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu30 errvalmxh[34] dfx__mash_order_plus_one fractionlastordermxh[11] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu28 errvalmxh[32] dfx__mash_order_plus_one fractionlastordermxh[9] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu27 errvalmxh[31] dfx__mash_order_plus_one fractionlastordermxh[8] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu26 errvalmxh[30] dfx__mash_order_plus_one fractionlastordermxh[7] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu25 errvalmxh[29] dfx__mash_order_plus_one fractionlastordermxh[6] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu23 errvalmxh[27] dfx__mash_order_plus_one fractionlastordermxh[4] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu21 errvalmxh[25] dfx__mash_order_plus_one fractionlastordermxh[2] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu20 errvalmxh[24] dfx__mash_order_plus_one fractionlastordermxh[1] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu51 errvalmxh[23] dfx__mash_order_plus_one fractionlastordermxh[0] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu40 errvalmxh[44] dfx__mash_order_plus_one fractionlastordermxh[21] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu39 errvalmxh[43] dfx__mash_order_plus_one fractionlastordermxh[20] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu37 errvalmxh[41] dfx__mash_order_plus_one fractionlastordermxh[18] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu36 errvalmxh[40] dfx__mash_order_plus_one fractionlastordermxh[17] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu35 errvalmxh[39] dfx__mash_order_plus_one fractionlastordermxh[16] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu33 errvalmxh[37] dfx__mash_order_plus_one fractionlastordermxh[14] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu29 errvalmxh[33] dfx__mash_order_plus_one fractionlastordermxh[10] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu24 errvalmxh[28] dfx__mash_order_plus_one fractionlastordermxh[5] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu22 errvalmxh[26] dfx__mash_order_plus_one fractionlastordermxh[3] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu41 dmfix_synopsys_unconnected_33 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xu3 errvalmxh[45] dfx__mash_order_plus_one fractionlastordermxh[22] vdd vssx ringpll__b15and002ah1n02x5 m=1
Xu8 ratio_async_mux__ratiomxh[1] deltanmxh[2] n3 n2 mash__ratiomxh[1] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu9 ratio_async_mux__ratiomxh[0] deltanmxh[1] n7 n3 mash__ratiomxh[0] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu6 ratio_async_mux__ratiomxh[3] n12 n1 n4 mash__ratiomxh[3] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu7 ratio_async_mux__ratiomxh[2] deltanmxh_10 n2 n1 mash__ratiomxh[2] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu13 ratio_async_mux__ratiomxh[5] n12 n5 n6 mash__ratiomxh[5] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu12 ratio_async_mux__ratiomxh[4] n12 n4 n5 mash__ratiomxh[4] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu16 ratio_async_mux__ratiomxh[7] n12 n8 n9 mash__ratiomxh[7] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu14 ratio_async_mux__ratiomxh[6] n12 n6 n8 mash__ratiomxh[6] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu17 n12 ratio_async_mux__ratiomxh[8] n9 n10 mash__ratiomxh[8] vdd vssx ringpll__b15rm0023an1n04x5 m=1
Xu18 ratio_async_mux__ratiomxh[9] n10 n11 vdd vssx ringpll__b15xor002al1n02x5 m=1
Xu19 n11 n12 mash__ratiomxh[9] vdd vssx ringpll__b15xor002an1n02x5 m=1
Xsigma_delta_ord_1 p_abuf4 p_abuf13 p_abuf8 ratio_async_mux__fractionmxh[22] ratio_async_mux__fractionmxh[21] ratio_async_mux__fractionmxh[20] ratio_async_mux__fractionmxh[19] ratio_async_mux__fractionmxh[18] ratio_async_mux__fractionmxh[17] ratio_async_mux__fractionmxh[16] ratio_async_mux__fractionmxh[15] ratio_async_mux__fractionmxh[14] ratio_async_mux__fractionmxh[13] ratio_async_mux__fractionmxh[12] ratio_async_mux__fractionmxh[11] ratio_async_mux__fractionmxh[10] ratio_async_mux__fractionmxh[9] ratio_async_mux__fractionmxh[8] ratio_async_mux__fractionmxh[7] ratio_async_mux__fractionmxh[6] ratio_async_mux__fractionmxh[5] ratio_async_mux__fractionmxh[4] ratio_async_mux__fractionmxh[3] ratio_async_mux__fractionmxh[2] ratio_async_mux__fractionmxh[1] ratio_async_mux__fractionmxh[0] errvalmxh[22] errvalmxh[21] errvalmxh[20] errvalmxh[19] errvalmxh[18] errvalmxh[17] errvalmxh[16] errvalmxh[15] errvalmxh[14] errvalmxh[13] errvalmxh[12] errvalmxh[11] errvalmxh[10] errvalmxh[9] errvalmxh[8] errvalmxh[7] errvalmxh[6] errvalmxh[5] errvalmxh[4] errvalmxh[3] errvalmxh[2] errvalmxh[1] errvalmxh[0] carrymxh[0] vdd vssx p_abuf0 p_abuf0 p_abuf12 p_abuf7 p_abuf14 p_abuf11 p_abuf14 ringpll__sigma_delta_23_2
Xsigma_delta_ord_np1 ctsbuf_net_1534 p_abuf6 reg_req_ack__mashstateresetmxh fractionlastordermxh[22] fractionlastordermxh[21] fractionlastordermxh[20] fractionlastordermxh[19] fractionlastordermxh[18] fractionlastordermxh[17] fractionlastordermxh[16] fractionlastordermxh[15] fractionlastordermxh[14] fractionlastordermxh[13] fractionlastordermxh[12] fractionlastordermxh[11] fractionlastordermxh[10] fractionlastordermxh[9] fractionlastordermxh[8] fractionlastordermxh[7] fractionlastordermxh[6] fractionlastordermxh[5] fractionlastordermxh[4] fractionlastordermxh[3] fractionlastordermxh[2] fractionlastordermxh[1] fractionlastordermxh[0] dmfix_synopsys_unconnected_1 dmfix_synopsys_unconnected_2 dmfix_synopsys_unconnected_3 dmfix_synopsys_unconnected_4 dmfix_synopsys_unconnected_5 dmfix_synopsys_unconnected_6 dmfix_synopsys_unconnected_7 dmfix_synopsys_unconnected_8 dmfix_synopsys_unconnected_9 dmfix_synopsys_unconnected_10 dmfix_synopsys_unconnected_11 dmfix_synopsys_unconnected_12 dmfix_synopsys_unconnected_13 dmfix_synopsys_unconnected_14 dmfix_synopsys_unconnected_15 dmfix_synopsys_unconnected_16 dmfix_synopsys_unconnected_17 dmfix_synopsys_unconnected_18 dmfix_synopsys_unconnected_19 dmfix_synopsys_unconnected_20 dmfix_synopsys_unconnected_21 dmfix_synopsys_unconnected_22 dmfix_synopsys_unconnected_23 carrymxh[2] vdd vssx lockxxnnnl p_abuf2 p_abuf1 p_abuf6 p_abuf12 p_abuf9 p_abuf12 ringpll__sigma_delta_23_0
Xcarrydelaylaststagemxh_reg p_abuf4 net87 carrydeltadelaymxh_2__0 p_abuf6 vdd vssx ringpll__b15fqn003al1n02x5 m=1
Xu499 carrymxh[2] net87 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xmash_carry_blocks1xflopsxmash_carry_stage ssc_mod_dfx__clkmodmxh p_abuf6 p_abuf8 dmfix_synopsys_unconnected_24 carrymxh[2] dmfix_synopsys_unconnected_25 carrydeltadelaymxh_2__0 carrymxh[1] carrydeltamxh_1__2 carrydeltamxh_1__1 carrydeltamxh_1__0 carrydeltadelaymxh_1__2 carrydeltadelaymxh_1__1 carrydeltadelaymxh_1__0 vdd vssx p_abuf4 p61 ringpll__mash_carry_2_0
Xmash_carry_blocks0xno_flopsxmash_carry_stage_1 dmfix_synopsys_unconnected_26 dmfix_synopsys_unconnected_27 dmfix_synopsys_unconnected_28 carrydeltamxh_1__2 carrydeltamxh_1__1 carrydeltamxh_1__0 carrydeltadelaymxh_1__2 carrydeltadelaymxh_1__1 carrydeltadelaymxh_1__0 carrymxh[0] deltanmxh_10 deltanmxh[2] deltanmxh[1] deltanmxh[0] dmfix_synopsys_unconnected_29 dmfix_synopsys_unconnected_30 dmfix_synopsys_unconnected_31 dmfix_synopsys_unconnected_32 vdd vssx ringpll__mash_carry_3_1
Xu50 dfx__mash_order_plus_one p_abuf15 clklastordermxh vdd vssx ringpll__b15and002al1n04x5 m=1
Xcts_cts_buf_4871185 clklastordermxh ctsbuf_net_1534 vdd vssx ringpll__b15cbf000ah1n08x5 m=1
Xsigma_delta_blocks1xsigma_delta p_abuf4 p_abuf3 p_abuf14 errvalmxh[22] errvalmxh[21] errvalmxh[20] errvalmxh[19] errvalmxh[18] errvalmxh[17] errvalmxh[16] errvalmxh[15] errvalmxh[14] errvalmxh[13] errvalmxh[12] errvalmxh[11] errvalmxh[10] errvalmxh[9] errvalmxh[8] errvalmxh[7] errvalmxh[6] errvalmxh[5] errvalmxh[4] errvalmxh[3] errvalmxh[2] errvalmxh[1] errvalmxh[0] errvalmxh[45] errvalmxh[44] errvalmxh[43] errvalmxh[42] errvalmxh[41] errvalmxh[40] errvalmxh[39] errvalmxh[38] errvalmxh[37] errvalmxh[36] errvalmxh[35] errvalmxh[34] errvalmxh[33] errvalmxh[32] errvalmxh[31] errvalmxh[30] errvalmxh[29] errvalmxh[28] errvalmxh[27] errvalmxh[26] errvalmxh[25] errvalmxh[24] errvalmxh[23] carrymxh[1] vdd vssx p_abuf0 p_abuf5 p_abuf12 reg_req_ack__mashstateresetmxh p_abuf10 p_abuf11 p_abuf1 ringpll__sigma_delta_23_1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_skewadjust2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_skewadjust2 clkfbd clkrefd clkfb clkref ctrl[4] ctrl[3] ctrl[2] ctrl[1] ctrl[0] vccpll vssx
* .PININFO clkfb:I clkref:I ctrl[4]:I ctrl[3]:I ctrl[2]:I ctrl[1]:I ctrl[0]:I vccpll:I vssx:I clkfbd:O clkrefd:O
Xorn02 ctrli[3] ctrli[2] pre1_0b vccpll vssx ringpll__b15orn002al1n08x5 m=1
Xorn03 ctrli[1] ctrli[0] pre0_0b vccpll vssx ringpll__b15orn002al1n08x5 m=1
Xnonb1 ctrli[3] ctrli[2] net32 vccpll vssx ringpll__b15nonb02al1n02x5 m=1
Xnonb0 ctrli[2] ctrli[3] net33 vccpll vssx ringpll__b15nonb02al1n02x5 m=1
Xnonb2 ctrli[1] ctrli[0] net50 vccpll vssx ringpll__b15nonb02al1n02x5 m=1
Xnonb3 ctrli[0] ctrli[1] net51 vccpll vssx ringpll__b15nonb02al1n02x5 m=1
Xidel14 del[16] del[15] net36 del[14] pre0_3b pre1_3b vssx vssx vccpll vssx ringpll__pll_skadj_unit
Xidel13 del[17] del[14] net37 del[13] pre0_2b pre1_3b del[16] net36 vccpll vssx ringpll__pll_skadj_unit
Xidel12 del[18] del[13] net35 del[12] pre0_1b pre1_3b del[17] net37 vccpll vssx ringpll__pll_skadj_unit
Xidel11 del[19] del[12] net38 del[11] pre0_0b pre1_3b del[18] net35 vccpll vssx ringpll__pll_skadj_unit
Xidel10 del[20] del[11] net39 del[10] pre0_3b pre1_2b del[19] net38 vccpll vssx ringpll__pll_skadj_unit
Xidel9 del[21] del[10] net40 del[9] pre0_2b pre1_2b del[20] net39 vccpll vssx ringpll__pll_skadj_unit
Xidel8 net43 del[9] net42 del[8] pre0_1b pre1_2b del[21] net40 vccpll vssx ringpll__pll_skadj_unit
Xidel7 del[22] del[8] net34 del[7] pre0_0b pre1_2b net43 net42 vccpll vssx ringpll__pll_skadj_unit
Xidel6 del[23] del[7] net44 del[6] pre0_3b pre1_1b del[22] net34 vccpll vssx ringpll__pll_skadj_unit
Xidel5 del[24] del[6] net45 del[5] pre0_2b pre1_1b del[23] net44 vccpll vssx ringpll__pll_skadj_unit
Xidel4 del[25] del[5] net41 del[4] pre0_1b pre1_1b del[24] net45 vccpll vssx ringpll__pll_skadj_unit
Xidel3 del[26] del[4] net46 del[3] pre0_0b pre1_1b del[25] net41 vccpll vssx ringpll__pll_skadj_unit
Xidel2 del[27] del[3] net47 del[2] pre0_3b pre1_0b del[26] net46 vccpll vssx ringpll__pll_skadj_unit
Xidel1 del[28] del[2] net48 del[1] pre0_2b pre1_0b del[27] net47 vccpll vssx ringpll__pll_skadj_unit
Xidel0 clkdelout del[1] net49 clkdelin pre0_1b pre1_0b del[28] net48 vccpll vssx ringpll__pll_skadj_unit
Xmdn00 net20 net19 clkdelin ctrli[4] vccpll vssx ringpll__b15mdn022al1n02x5 m=1
Xmbn02 clkref clkdelout clkrefd sel_norefdel vccpll vssx ringpll__b15mbn022al1n06x5 m=1
Xmbn01 clkfb clkdelout clkfbd sel_nofbdel vccpll vssx ringpll__b15mbn022al1n06x5 m=1
Xorn01 nodel ctrl4b sel_nofbdel vccpll vssx ringpll__b15orn002al1n02x5 m=1
Xorn00 nodel ctrli[4] sel_norefdel vccpll vssx ringpll__b15orn002al1n02x5 m=1
Xinv01 ctrli[4] ctrl4b vccpll vssx ringpll__b15inv000al1n02x5 m=1
Xbfn00[4] ctrl[4] ctrli[4] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[3] ctrl[3] ctrli[3] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[2] ctrl[2] ctrli[2] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[1] ctrl[1] ctrli[1] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[0] ctrl[0] ctrli[0] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xnanb1 nodel clkref net19 vccpll vssx ringpll__b15nanb02al1n02x5 m=1
Xnanb0 nodel clkfb net20 vccpll vssx ringpll__b15nanb02al1n02x5 m=1
Xnor00 ctrli[3] ctrli[2] ctrli[1] ctrli[0] nodel vccpll vssx ringpll__b15nor004al1n06x5 m=1
Xinv00 net32 pre1_2b vccpll vssx ringpll__b15inv000al1n08x5 m=1
Xinv02 net33 pre1_1b vccpll vssx ringpll__b15inv000al1n08x5 m=1
Xinv04 net51 pre0_1b vccpll vssx ringpll__b15inv000al1n08x5 m=1
Xinv03 net50 pre0_2b vccpll vssx ringpll__b15inv000al1n08x5 m=1
Xnand0 ctrli[3] ctrli[2] pre1_3b vccpll vssx ringpll__b15nand02al1n08x5 m=1
Xnand1 ctrli[1] ctrli[0] pre0_3b vccpll vssx ringpll__b15nand02al1n08x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljpllpfdclkdly
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljpllpfdclkdly dlyclkout clkin pgdly0 pgdly1 vccxx vssx
* .PININFO clkin:I pgdly0:I pgdly1:I vccxx:I vssx:I dlyclkout:O
Xinv05 pgdly1 pgdly1b vccxx vssx ringpll__b15inv000al1n04x5 m=1
Xinv04 pgdly0 pgdly0b vccxx vssx ringpll__b15inv000al1n04x5 m=1
Xnor01 pgdly0b pgdly1b dlysel3 vccxx vssx ringpll__b15nor002al1n02x5 m=1
Xinv00 pgdly1b dlysel2 vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xdly3 clkdly3 clkdly2buf vccxx vssx ringpll__pllx22ljpllunitdly
Xdly2 clkdly2 clkdly1buf vccxx vssx ringpll__pllx22ljpllunitdly
Xdly1 clkdly1 clkinbuf vccxx vssx ringpll__pllx22ljpllunitdly
Xmbn03 clk12 clk34 dlyclkout pgdly1b vccxx vssx ringpll__b15mbn022an1n04x5 m=1
Xbfm23 clkin clkinbuff1 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xbfm22 clkinbuff1 clkinbuff2 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xbfm20 clkinbuff2 clkinbuff3 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xnand3 pgdly0b pgdly1b dlysel1 vccxx vssx ringpll__b15nand02al1n02x5 m=1
Xmbn00 clkinbuff3 clkdly1 clk12 pgdly0b vccxx vssx ringpll__b15mbn022an1n02x5 m=1
Xmbn01 clkdly2 clkdly3 clk34 pgdly0b vccxx vssx ringpll__b15mbn022an1n02x5 m=1
Xinv01 clkinb clkinbuf vccxx vssx ringpll__b15inv000an1n02x5 m=1
Xinv02 clkdly1b clkdly1buf vccxx vssx ringpll__b15inv000an1n02x5 m=1
Xinv03 clkdly2b clkdly2buf vccxx vssx ringpll__b15inv000an1n02x5 m=1
Xnand1 clkinbuff3 dlysel1 clkinb vccxx vssx ringpll__b15nand02an1n02x5 m=1
Xnand0 clkdly1 dlysel2 clkdly1b vccxx vssx ringpll__b15nand02an1n02x5 m=1
Xnand2 clkdly2 dlysel3 clkdly2b vccxx vssx ringpll__b15nand02an1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_cnlx74ljpllpfdlockrstgen
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_cnlx74ljpllpfdlockrstgen lockreset dnforlock t[3] t[2] t[1] upforlock vccxx vssx
* .PININFO dnforlock:I t[3]:I t[2]:I t[1]:I upforlock:I vccxx:I vssx:I lockreset:O
Xinv06 pherrdly1b pherrdly1buf vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinv05 pherrdly2b pherrdly2buf vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinv04 pherrdly3b pherrdly3buf vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinvt0 t[2] t2b vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinv02 dlydpherrpulse_b dlydpherrpulse vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinvt1 t[1] t1b vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xilockdelmux dlydpherrpulse_b vccxx vssx pherrdly5 pherrdly3 pherrdly2 pherrdly1 lockthsel[0] lockthsel[1] lockthsel[2] lockthsel[3] ringpll__pllx22_b15mdn004xl1n04x5
Xinv01 lockthsel[3] dlysel[1] vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv03 t2b dlysel[2] vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xdmfix_xor00 upforlock dnforlock pherrpulse vccxx vssx ringpll__b15xor002al1n03x5 m=1
Xi13 pherrdly5 pherrdly4 vccxx vssx ringpll__pllx22_cnlx74ljpllunitdly
Xidlyr3 pherrdly3 pherrdly2buf vccxx vssx ringpll__pllx22_cnlx74ljpllunitdly
Xidlyr2 pherrdly2 pherrdly1buf vccxx vssx ringpll__pllx22_cnlx74ljpllunitdly
Xidlyr1 pherrdly1 pherrpulse vccxx vssx ringpll__pllx22_cnlx74ljpllunitdly
Xi4 pherrdly4 pherrdly3buf vccxx vssx ringpll__pllx22_cnlx74ljpllunitdly
Xnand1 pherrdly1 dlysel[1] pherrdly1b vccxx vssx ringpll__b15nand02al1n03x5 m=1
Xnand3 pherrdly3 lockthsel[0] pherrdly3b vccxx vssx ringpll__b15nand02al1n03x5 m=1
Xnand2 pherrdly2 dlysel[2] pherrdly2b vccxx vssx ringpll__b15nand02al1n03x5 m=1
Xnand0 dlydpherrpulse pherrpulse lockreset_b vccxx vssx ringpll__b15nand02al1n03x5 m=1
Xnor11 t[1] t[2] lockthsel[3] vccxx vssx ringpll__b15nor002al1n03x5 m=1
Xnor10 t1b t[2] lockthsel[2] vccxx vssx ringpll__b15nor002al1n03x5 m=1
Xnor01 t2b t[1] lockthsel[1] vccxx vssx ringpll__b15nor002al1n03x5 m=1
Xnor00 t1b t2b lockthsel[0] vccxx vssx ringpll__b15nor002al1n03x5 m=1
Xinv00 lockreset_b lockreset vccxx vssx ringpll__b15inv000al1n05x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljcpi_jsa
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljcpi_jsa pbias vctrl ibias cpcurr0 cpcurr1 cpcurr2 cpcurr3 cpcurr4 cppwg dn en nbiastrim[1] nbiastrim[0] up vccpll vssx
* .PININFO cpcurr0:I cpcurr1:I cpcurr2:I cpcurr3:I cpcurr4:I cppwg:I dn:I en:I nbiastrim[1]:I nbiastrim[0]:I up:I vccpll:I vssx:I pbias:O vctrl:O
* .PININFO ibias:B
Xdrv1_lt vctrl vctrl dnbb_t ibias pbias cp1 upbb_t vccpll vssx ringpll__pllx22ljpll_cpslicequarter
Xdrv0_dummy_rt dmfix_dummy2_dn dmfix_dummy2_up dnbb_t ibias pbias vssx upbb_t vccpll vssx ringpll__pllx22ljpll_cpslicequarter
Xdrv1_rb vctrl vctrl dnbb_b ibias pbias cp1 upbb_b vccpll vssx ringpll__pllx22ljpll_cpslicequarter
Xnbias1_b ibias ibias nb1b ibias soft_vcc soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslicequarter
Xnbias0_t ibias ibias nb0b ibias soft_vcc soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslicequarter
Xnbias3 ibias ibias enbb ibias soft_vcc soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslicequarter
Xnbias1_t ibias ibias nb1b ibias soft_vcc soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslicequarter
Xdrv0_lb vctrl vctrl dnbb_b ibias pbias cp0 upbb_b vccpll vssx ringpll__pllx22ljpll_cpslicequarter
Xnbias0_b ibias ibias nb0b ibias soft_vcc soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslicequarter
Xinv09 upb_t upbb_t vccpll vssx ringpll__b15inv000an1n20x5 m=1
Xinv08 dnb_t dnbb_t vccpll vssx ringpll__b15inv000an1n20x5 m=1
Xinv04 upb_b upbb_b vccpll vssx ringpll__b15inv000an1n20x5 m=1
Xinv05 dnb_b dnbb_b vccpll vssx ringpll__b15inv000an1n20x5 m=1
Xcpbuff cp0 cp1 cp2 cp3 cp4 cpcurr0 cpcurr1 cpcurr2 cpcurr3 cpcurr4 vccpll vssx ringpll__pllx22ljpll_cpbuf
Xinv00 vssx soft_vcc vccpll vssx ringpll__b15inv000al1n48x5 m=1
Xinv07 dn dnb_t vccpll vssx ringpll__b15inv000an1n08x5 m=1
Xinv06 up upb_t vccpll vssx ringpll__b15inv000an1n08x5 m=1
Xinv02 up upb_b vccpll vssx ringpll__b15inv000an1n08x5 m=1
Xinv03 dn dnb_b vccpll vssx ringpll__b15inv000an1n08x5 m=1
Xincap ibias vssx ringpll__mfc_s2g_pcell_128
Xipcap pbias vccpll vssx ringpll__mfc_s2p_pcell_129
Xcplogic enbb nb0b nb1b nb2b pwgb pwgbb en soft_vcc nbiastrim[0] nbiastrim[1] cppwg vccpll vssx ringpll__pllx22ljpll_cplogic
Xdrv4_lb dmfix_dummyx4_dn3 dmfix_dummyx4_up3 dnbb_b ibias pbias cp4 upbb_b vccpll vssx ringpll__pllx22ljpll_cpslice
Xdrv3_rt vctrl vctrl dnbb_t ibias pbias cp3 upbb_t vccpll vssx ringpll__pllx22ljpll_cpslice
Xdrv2_rb vctrl vctrl dnbb_b ibias pbias cp2 upbb_b vccpll vssx ringpll__pllx22ljpll_cpslice
Xdrv4_rt dmfix_dummyx4_dn2 dmfix_dummyx4_up2 dnbb_t ibias pbias cp4 upbb_t vccpll vssx ringpll__pllx22ljpll_cpslice
Xdrv4_rb dmfix_dummyx4_dn4 dmfix_dummyx4_up4 dnbb_b ibias pbias cp4 upbb_b vccpll vssx ringpll__pllx22ljpll_cpslice
Xnbias4_b ibias ibias enbb ibias soft_vcc soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslice
Xnbias2 ibias ibias nb2b ibias soft_vcc soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslice
Xnbias4_t ibias ibias enbb ibias soft_vcc soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslice
Xdrv4_lt dmfix_dummyx4_dn1 dmfix_dummyx4_up1 dnbb_t ibias pbias cp4 upbb_t vccpll vssx ringpll__pllx22ljpll_cpslice
Xpbias_dummy_b[2] vssx vssx vssx ibias pbias soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslice
Xpbias_dummy_b[1] vssx vssx vssx ibias pbias soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslice
Xpbias_dummy_t[2] vssx vssx vssx ibias pbias soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslice
Xpbias_dummy_t[1] vssx vssx vssx ibias pbias soft_vcc vssx vccpll vssx ringpll__pllx22ljpll_cpslice
Xpbias_t[2] pbias pbias pwgbb ibias pbias soft_vcc pwgbb vccpll vssx ringpll__pllx22ljpll_cpslice
Xpbias_t[1] pbias pbias pwgbb ibias pbias soft_vcc pwgbb vccpll vssx ringpll__pllx22ljpll_cpslice
Xdrv2_dummy_lt dmfix_dummy1_dn dmfix_dummy1_up dnbb_t ibias pbias vssx upbb_t vccpll vssx ringpll__pllx22ljpll_cpslice
Xdrv3_lb vctrl vctrl dnbb_b ibias pbias cp3 upbb_b vccpll vssx ringpll__pllx22ljpll_cpslice
Xpbias_b[2] pbias pbias pwgbb ibias pbias soft_vcc pwgbb vccpll vssx ringpll__pllx22ljpll_cpslice
Xpbias_b[1] pbias pbias pwgbb ibias pbias soft_vcc pwgbb vccpll vssx ringpll__pllx22ljpll_cpslice
Mmp1[1] npwd1 enbb vccpll vccpll plp W=135n L=40n M=1
Mmp1[0] npwd1a enbb vccpll vccpll plp W=135n L=40n M=1
Mmp0[1] pbias enbb npwd1 vccpll plp W=135n L=40n M=1
Mmp0[0] pbias enbb npwd1a vccpll plp W=135n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_startup
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_startup vctl0 en fbclk fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] rdactovctlen refclk tup vccpll vssx
* .PININFO en:I fbclk:I fz_startup[5]:I fz_startup[4]:I fz_startup[3]:I fz_startup[2]:I fz_startup[1]:I fz_startup[0]:I rdactovctlen:I refclk:I tup:I
* .PININFO vccpll:I vssx:I vctl0:O
Xinv04 rdactovctlen rdacenb vccpll vssx ringpll__b15inv000al1n02x5 m=1
Xinv01 en enb vccpll vssx ringpll__b15inv000al1n02x5 m=1
Mmn0 vr npd vssx vssx ntgmv W=270n L=120n M=4
Xitcount tupenable enb fbclk refclk fz_startup[3] tup vccpll vssx ringpll__pll_tcount
Xand00 tup tupenable tupi vccpll vssx ringpll__b15and002al1n02x5 m=1
Xnand1 fz_startup[4] fz_startup[5] tripeni vccpll vssx ringpll__b15nand02al1n02x5 m=1
Xinv00 enb pub vccpll vssx ringpll__b15inv000al1n04x5 m=1
Xnor00 enb rdactovctlen n4 npd vccpll vssx ringpll__b15nor003al1n04x5 m=1
Xand02 tripeni rdacenb en tripen vccpll vssx ringpll__b15and003al1n04x5 m=1
Mmp0 vctl0 pub vccpll vccpll ptgmv W=270n L=120n M=4
Xires vctl0 fz_startup[2] fz_startup[1] fz_startup[0] vccpll vr vssx ringpll__pll_sures
Xitrip trippd enb fz_startup[4] fz_startup[5] tripen vccpll vctl0 vssx ringpll__pll_sutrip
Xnor01 tupi trippd n4 vccpll vssx ringpll__b15nor002al1n02x3 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_angcoreswc
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_angcoreswc clk1dfb clk2dfb en_dly_b sdoutang chop ckph1 ckph2 en_b sdfbk vangin_a vbias_a vcchv vccxx vref_a vssx
* .PININFO chop:I ckph1:I ckph2:I en_b:I sdfbk:I vangin_a:I vbias_a:I vcchv:I vccxx:I vref_a:I vssx:I clk1dfb:O clk2dfb:O en_dly_b:O sdoutang:O
Xinv00 en_b force0b vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xinvdrv n5 n6 vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xinvc1 n3 ncmpin vccxx vssx ringpll__adc_invcsc
Xinvc3 n5 n4 vccxx vssx ringpll__adc_invcsc
Xinvc2 n4 n3 vccxx vssx ringpll__adc_invcsc
Xbfm24 en_b en_dly_b vccxx vssx ringpll__b15bfm201al1n08x5 m=1
Xand00 n6 force0b sdoutang vccxx vssx ringpll__b15and002al1n08x5 m=1
Xand02 ckph2 force0b clk2dfb vccxx vssx ringpll__b15and002al1n08x5 m=1
Xand01 ckph1 force0b clk1dfb vccxx vssx ringpll__b15and002al1n08x5 m=1
Xiamp ncmpin en_dly_b nbkt vbias_a vccxx vssx ringpll__adc_invamp
Xiswbktvref vref_a nbktin clk1d clk2d sdfdbk_dly chopd vcchv vssx ringpll__adc_swfbkhv
Xi98 ntnk ncmpin vccxx vccxx vssx ringpll__mfc_s2s_pcell_93
Xi91 nbktin nbkt vccxx vccxx vssx ringpll__mfc_s2s_pcell_94
Xiswbktvin vangin_a nbktin clk2d clk1d chopd vcchv vssx ringpll__adc_swhv
Xiswtnkpar nbkt ncmpin clk2d clk1d vssx vcchv vssx ringpll__adc_swhv
Xiswtnkser nbkt ntnk clk1d clk2d vssx vcchv vssx ringpll__adc_swhv
Xsg003 vssx chop chopd vccxx vcchv vssx ringpll__b15sg00d0ag1d02x5 m=1
Xsg001 vssx ckph1 clk1d vccxx vcchv vssx ringpll__b15sg00d0ag1d02x5 m=1
Xsg000 vssx sdfbk sdfdbk_dly vccxx vcchv vssx ringpll__b15sg00d0ag1d02x5 m=1
Xsg002 vssx ckph2 clk2d vccxx vcchv vssx ringpll__b15sg00d0ag1d02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_novclkgen
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_novclkgen ckdig ckph1 ckph2 ckin ckph1d_fb ckph2d_fb freeze vccxx vssx
* .PININFO ckin:I ckph1d_fb:I ckph2d_fb:I freeze:I vccxx:I vssx:I ckdig:O ckph1:O ckph2:O
Xand00 n41 freeze_b ckdig vccxx vssx ringpll__b15and002al1n16x5 m=1
Xiclkgenprim1 n41 n40 ckin_byp ckph1d_fb_b ckph2d_fb_b vccxx vssx ringpll__adc_novclkgenprim
Xcbf01 n40 ckph2 vccxx vssx ringpll__b15cbf000al1n16x5 m=1
Xcbf00 n41 ckph1 vccxx vssx ringpll__b15cbf000al1n16x5 m=1
Xi92 freeze freeze_b vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xinn0 ckph1d_fb ckph1d_fb_b vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xinn1 ckph2d_fb ckph2d_fb_b vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xcbf02 ckin ckin_byp vccxx vssx ringpll__b15cbf000al1n06x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vco_lj
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vco_lj clkvco vro cb[2] cb[1] cb[0] en pcsdegen[2] pcsdegen[1] pcsdegen[0] pgb[3] pgb[2] pgb[1] pgb[0] vccpll vctl vssx
* .PININFO cb[2]:I cb[1]:I cb[0]:I en:I pcsdegen[2]:I pcsdegen[1]:I pcsdegen[0]:I pgb[3]:I pgb[2]:I pgb[1]:I pgb[0]:I vccpll:I vctl:I vssx:I clkvco:O
* .PININFO vro:O
Mmn0 vro enb vssx vssx nlp W=180n L=40n M=1
Xrosc clkvco cbbuf[2] cbbuf[1] cbbuf[0] vro vssx ringpll__vcoro_lj
Xbfn01[2] cb[2] cbbuf[2] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn01[1] cb[1] cbbuf[1] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn01[0] cb[0] cbbuf[0] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[3] pgb[3] pgbi[3] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[2] pgb[2] pgbi[2] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[1] pgb[1] pgbi[1] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[0] pgb[0] pgbi[0] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xinv01[2] pcsdegen[2] dgenb[2] vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xinv01[1] pcsdegen[1] dgenb[1] vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xinv01[0] pcsdegen[0] dgenb[0] vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xinv00 en enb vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xidummy[7] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit_p_s6
Xidummy[6] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit_p_s6
Xidummy[5] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit_p_s6
Xidummy[4] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit_p_s6
Xidummy[3] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit_p_s6
Xidummy[2] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit_p_s6
Xidummy[1] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit_p_s6
Xidummy[0] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit_p_s6
Xpg1[16] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[15] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[14] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[13] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[12] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[11] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[10] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[9] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[8] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[7] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[6] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[5] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[4] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[3] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[2] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg1[1] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[32] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[31] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[30] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[29] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[28] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[27] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[26] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[25] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[24] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[23] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[22] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[21] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[20] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[19] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[18] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[17] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[16] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[15] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[14] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[13] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[12] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[11] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[10] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[9] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[8] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[7] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[6] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[5] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[4] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[3] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[2] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg2[1] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg0[8] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[0] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg0[7] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[0] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg0[6] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[0] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg0[5] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[0] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg0[4] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[0] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg0[3] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[0] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg0[2] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[0] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg0[1] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[0] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[64] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[63] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[62] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[61] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[60] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[59] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[58] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[57] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[56] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[55] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[54] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[53] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[52] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[51] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[50] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[49] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[48] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[47] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[46] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[45] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[44] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[43] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[42] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[41] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[40] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[39] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[38] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[37] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[36] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[35] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[34] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[33] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[32] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[31] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[30] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[29] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[28] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[27] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[26] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[25] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[24] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[23] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[22] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[21] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[20] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[19] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[18] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[17] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[16] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[15] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[14] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[13] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[12] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[11] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[10] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[9] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[8] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[7] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[6] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[5] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[4] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[3] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[2] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
Xpg3[1] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit_p_s6
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_inc
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_inc cntrwrap_b digout[9] digout[8] digout[7] digout[6] digout[5] digout[4] digout[3] digout[2] digout[1] digout[0] clk inc load_b rst_b vccxx vssx
* .PININFO clk:I inc:I load_b:I rst_b:I vccxx:I vssx:I cntrwrap_b:O digout[9]:O digout[8]:O digout[7]:O digout[6]:O digout[5]:O digout[4]:O
* .PININFO digout[3]:O digout[2]:O digout[1]:O digout[0]:O
Xbfn01 inc cin vccxx vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn03 clk ckbuf vccxx vssx ringpll__b15bfn000al1n12x5 m=1
Xinv00 cout[9] cntrwrap_b vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xiinc[9] cout[9] digout[9] cout[8] ckbuf cin load_b_i rst_b_i vccxx vssx ringpll__adc_incprim
Xiinc[8] cout[8] digout[8] cout[7] ckbuf cin load_b_i rst_b_i vccxx vssx ringpll__adc_incprim
Xiinc[7] cout[7] digout[7] cout[6] ckbuf cin load_b_i rst_b_i vccxx vssx ringpll__adc_incprim
Xiinc[6] cout[6] digout[6] cout[5] ckbuf cin load_b_i rst_b_i vccxx vssx ringpll__adc_incprim
Xiinc[5] cout[5] digout[5] cout[4] ckbuf cin load_b_i rst_b_i vccxx vssx ringpll__adc_incprim
Xiinc[4] cout[4] digout[4] cout[3] ckbuf cin load_b_i rst_b_i vccxx vssx ringpll__adc_incprim
Xiinc[3] cout[3] digout[3] cout[2] ckbuf cin load_b_i rst_b_i vccxx vssx ringpll__adc_incprim
Xiinc[2] cout[2] digout[2] cout[1] ckbuf cin load_b_i rst_b_i vccxx vssx ringpll__adc_incprim
Xiinc[1] cout[1] digout[1] cout[0] ckbuf cin load_b_i rst_b_i vccxx vssx ringpll__adc_incprim
Xiinc[0] cout[0] digout[0] cin ckbuf cin load_b_i rst_b_i vccxx vssx ringpll__adc_incprim
Xbfn04 load_b load_b_i vccxx vssx ringpll__b15bfn000al1n08x5 m=1
Xbfn02 rst_b rst_b_i vccxx vssx ringpll__b15bfn000al1n08x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vco
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vco clkvco vro cb[2] cb[1] cb[0] en pcsdegen[2] pcsdegen[1] pcsdegen[0] pgb[3] pgb[2] pgb[1] pgb[0] vccpll vctl vssx
* .PININFO cb[2]:I cb[1]:I cb[0]:I en:I pcsdegen[2]:I pcsdegen[1]:I pcsdegen[0]:I pgb[3]:I pgb[2]:I pgb[1]:I pgb[0]:I vccpll:I vctl:I vssx:I clkvco:O
* .PININFO vro:O
Xinv01[2] pcsdegen[2] dgenb[2] vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xinv01[1] pcsdegen[1] dgenb[1] vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xinv01[0] pcsdegen[0] dgenb[0] vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xinv00 en enb vccpll vssx ringpll__b15inv000al1n06x5 m=1
Xrosc clkvco cbbuf[2] cbbuf[1] cbbuf[0] vro vssx ringpll__vcoro
Xidummy[5] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit
Xidummy[4] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit
Xidummy[3] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit
Xidummy[2] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit
Xidummy[1] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit
Xidummy[0] vccpll vssx vssx vssx vssx vssx vccpll vssx vssx ringpll__vcopullupunit
Xpg2[4] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit
Xpg2[3] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit
Xpg2[2] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit
Xpg2[1] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[2] vccpll vctl vssx ringpll__vcopullupunit
Xpg1[2] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit
Xpg1[1] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[1] vccpll vctl vssx ringpll__vcopullupunit
Xpg0 vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[0] vccpll vctl vssx ringpll__vcopullupunit
Xpg3[8] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit
Xpg3[7] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit
Xpg3[6] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit
Xpg3[5] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit
Xpg3[4] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit
Xpg3[3] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit
Xpg3[2] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit
Xpg3[1] vro dgenb[2] dgenb[1] dgenb[0] enb pgbi[3] vccpll vctl vssx ringpll__vcopullupunit
Mmn0 vro enb vssx vssx nlp W=180n L=40n M=1
Xbfn01[2] cb[2] cbbuf[2] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn01[1] cb[1] cbbuf[1] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn01[0] cb[0] cbbuf[0] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[3] pgb[3] pgbi[3] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[2] pgb[2] pgbi[2] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[1] pgb[1] pgbi[1] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
Xbfn00[0] pgb[0] pgbi[0] vccpll vssx ringpll__b15bfn000al1n06x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22ldo_pll_main_singleamp
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22ldo_pll_main_singleamp test_out vdd_ldo_out_o ibias_1u d_bypass_i d_enable_i d_imess_en_i d_startpulse_i feedback lp_brk_amp v_ref0v6_i vdd_hv vssx
* .PININFO d_bypass_i:I d_enable_i:I d_imess_en_i:I d_startpulse_i:I feedback:I lp_brk_amp:I v_ref0v6_i:I vdd_hv:I vssx:I test_out:O vdd_ldo_out_o:O
* .PININFO ibias_1u:B
Xi2393 feedback vdd_ldo_out_o nc1 nc2 vssx ringpll__mfc_s2s_pcell_26
Xi183 pd_o vdd_hv vssx d_enable_i ringpll__xb15inv000xu1n05x5
Xinn4 pd_bp vdd_hv vssx pd_p ringpll__xb15inv000xu1n05x5
Xinn3 pu_bp vdd_hv vssx pu_p ringpll__xb15inv000xu1n05x5
Xinn2 pu_p vdd_hv vssx d_enable_i ringpll__xb15inv000xu1n05x5
Xinn1 pu vdd_hv vssx pd ringpll__xb15inv000xu1n05x5
Xinn0 byp_b vdd_hv vssx d_bypass_i ringpll__xb15inv000xu1n05x5
Xicomp out2p vdd_hv ringpll__x22ldo_ampcompensation
Xinin_dummy[16] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[15] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[14] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[13] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[12] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[11] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[10] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[9] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[8] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[7] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[6] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[5] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[4] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[3] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[2] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinin_dummy[1] nsource2 vssx vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[32] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[31] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[30] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[29] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[28] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[27] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[26] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[25] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[24] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[23] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[22] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[21] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[20] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[19] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[18] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[17] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[16] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[15] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[14] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[13] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[12] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[11] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[10] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[9] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[8] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[7] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[6] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[5] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[4] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[3] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[2] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp2[1] in2p_mid lp_brk_amp nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[18] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[17] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[16] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[15] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[14] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[13] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[12] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[11] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[10] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[9] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[8] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[7] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[6] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[5] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[4] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[3] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[2] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi151[1] n6 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[18] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[17] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[16] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[15] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[14] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[13] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[12] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[11] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[10] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[9] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[8] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[7] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[6] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[5] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[4] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[3] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[2] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xi150[1] n9 n9 vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[24] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[23] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[22] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[21] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[20] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[19] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[18] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[17] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[16] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[15] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[14] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[13] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[12] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[11] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[10] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[9] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[8] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[7] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[6] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[5] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[4] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[3] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[2] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinsource[1] nsource2 ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[32] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[31] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[30] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[29] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[28] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[27] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[26] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[25] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[24] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[23] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[22] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[21] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[20] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[19] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[18] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[17] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[16] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[15] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[14] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[13] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[12] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[11] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[10] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[9] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[8] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[7] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[6] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[5] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[4] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[3] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[2] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn2[1] in2n_mid v_ref0v6_i nsource2 vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinbias[4] ibias_1u ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinbias[3] ibias_1u ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinbias[2] ibias_1u ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xinbias[1] ibias_1u ibias_1u vssx vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[32] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[31] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[30] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[29] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[28] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[27] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[26] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[25] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[24] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[23] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[22] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[21] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[20] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[19] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[18] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[17] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[16] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[15] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[14] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[13] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[12] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[11] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[10] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[9] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[8] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[7] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[6] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[5] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[4] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[3] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[2] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininp1[1] out2m lp_brk_amp in2p_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[32] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[31] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[30] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[29] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[28] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[27] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[26] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[25] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[24] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[23] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[22] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[21] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[20] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[19] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[18] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[17] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[16] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[15] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[14] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[13] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[12] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[11] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[10] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[9] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[8] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[7] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[6] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[5] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[4] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[3] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[2] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xininn1[1] out2p v_ref0v6_i in2n_mid vssx ringpll__x22imc_ana_n144_mult1_4stack_width m=1
Xicnbias3 ibias_1u vssx ringpll__mfc_s2g_pcell_29
Mqp2[4] ipbypass_g pd_bp vdd_hv vdd_hv ptgmv W=180n L=120n M=1
Mqp2[3] ipbypass_g pd_bp vdd_hv vdd_hv ptgmv W=180n L=120n M=1
Mqp2[2] ipbypass_g pd_bp vdd_hv vdd_hv ptgmv W=180n L=120n M=1
Mqp2[1] ipbypass_g pd_bp vdd_hv vdd_hv ptgmv W=180n L=120n M=1
Mqp0_dummy out2m vdd_hv vdd_hv vdd_hv ptgmv W=180n L=120n M=1
Mqp1[4] out2p pu_bp vdd_hv vdd_hv ptgmv W=180n L=120n M=1
Mqp1[3] out2p pu_bp vdd_hv vdd_hv ptgmv W=180n L=120n M=1
Mqp1[2] out2p pu_bp vdd_hv vdd_hv ptgmv W=180n L=120n M=1
Mqp1[1] out2p pu_bp vdd_hv vdd_hv ptgmv W=180n L=120n M=1
Mqp0 out2m pu vdd_hv vdd_hv ptgmv W=180n L=120n M=1
Xidecap4 vdd_ldo_out_o vssx ringpll__pdecap_s2p_pcell_30
Xnan0 pd vdd_hv vssx byp_b d_enable_i ringpll__xb15nand02xu1n12x5
Xann0 pd_p vdd_hv vssx d_bypass_i d_enable_i ringpll__xb15nand02xu1n12x5
Xires vdd_ldo_out_o res vssx ringpll__x22heldo_res_1p6k
Xi129[20] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[19] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[18] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[17] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[16] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[15] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[14] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[13] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[12] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[11] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[10] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[9] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[8] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[7] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[6] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[5] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[4] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[3] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[2] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi129[1] n10 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[16] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[15] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[14] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[13] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[12] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[11] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[10] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[9] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[8] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[7] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[6] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[5] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[4] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[3] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[2] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi125[1] pld2_midn out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[16] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[15] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[14] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[13] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[12] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[11] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[10] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[9] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[8] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[7] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[6] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[5] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[4] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[3] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[2] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi126[1] pld2_midp out2m vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[20] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[19] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[18] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[17] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[16] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[15] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[14] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[13] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[12] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[11] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[10] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[9] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[8] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[7] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[6] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[5] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[4] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[3] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[2] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi120[1] test_out n6 n10 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[16] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[15] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[14] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[13] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[12] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[11] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[10] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[9] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[8] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[7] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[6] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[5] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[4] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[3] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[2] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi228[1] out2m out2m pld2_midn vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi130[6] n1 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi130[5] n1 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi130[4] n1 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi130[3] n1 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi130[2] n1 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi130[1] n1 out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi117[6] n6 n6 vdd_ldo_out_o vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi117[5] n6 n6 vdd_ldo_out_o vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi117[4] n6 n6 vdd_ldo_out_o vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi117[3] n6 n6 vdd_ldo_out_o vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi117[2] n6 n6 vdd_ldo_out_o vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi117[1] n6 n6 vdd_ldo_out_o vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[16] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[15] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[14] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[13] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[12] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[11] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[10] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[9] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[8] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[7] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[6] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[5] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[4] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[3] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[2] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi227[1] out2p out2m pld2_midp vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[250] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[249] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[248] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[247] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[246] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[245] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[244] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[243] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[242] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[241] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[240] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[239] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[238] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[237] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[236] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[235] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[234] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[233] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[232] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[231] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[230] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[229] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[228] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[227] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[226] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[225] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[224] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[223] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[222] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[221] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[220] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[219] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[218] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[217] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[216] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[215] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[214] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[213] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[212] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[211] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[210] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[209] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[208] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[207] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[206] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[205] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[204] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[203] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[202] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[201] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[200] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[199] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[198] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[197] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[196] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[195] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[194] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[193] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[192] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[191] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[190] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[189] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[188] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[187] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[186] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[185] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[184] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[183] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[182] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[181] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[180] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[179] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[178] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[177] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[176] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[175] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[174] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[173] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[172] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[171] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[170] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[169] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[168] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[167] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[166] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[165] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[164] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[163] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[162] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[161] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[160] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[159] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[158] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[157] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[156] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[155] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[154] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[153] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[152] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[151] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[150] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[149] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[148] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[147] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[146] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[145] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[144] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[143] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[142] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[141] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[140] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[139] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[138] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[137] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[136] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[135] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[134] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[133] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[132] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[131] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[130] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[129] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[128] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[127] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[126] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[125] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[124] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[123] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[122] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[121] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[120] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[119] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[118] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[117] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[116] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[115] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[114] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[113] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[112] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[111] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[110] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[109] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[108] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[107] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[106] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[105] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[104] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[103] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[102] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[101] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[100] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[99] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[98] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[97] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[96] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[95] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[94] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[93] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[92] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[91] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[90] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[89] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[88] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[87] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[86] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[85] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[84] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[83] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[82] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[81] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[80] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[79] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[78] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[77] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[76] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[75] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[74] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[73] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[72] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[71] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[70] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[69] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[68] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[67] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[66] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[65] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[64] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[63] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[62] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[61] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[60] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[59] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[58] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[57] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[56] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[55] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[54] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[53] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[52] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[51] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[50] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[49] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[48] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[47] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[46] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[45] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[44] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[43] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[42] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[41] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[40] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[39] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[38] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[37] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[36] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[35] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[34] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[33] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[32] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[31] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[30] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[29] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[28] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[27] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[26] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[25] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[24] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[23] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[22] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[21] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[20] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[19] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[18] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[17] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[16] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[15] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[14] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[13] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[12] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[11] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[10] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[9] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[8] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[7] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[6] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[5] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[4] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[3] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[2] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipout[1] vdd_ldo_out_o out2p vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[360] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[359] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[358] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[357] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[356] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[355] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[354] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[353] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[352] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[351] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[350] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[349] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[348] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[347] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[346] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[345] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[344] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[343] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[342] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[341] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[340] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[339] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[338] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[337] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[336] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[335] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[334] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[333] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[332] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[331] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[330] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[329] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[328] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[327] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[326] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[325] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[324] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[323] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[322] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[321] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[320] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[319] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[318] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[317] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[316] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[315] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[314] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[313] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[312] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[311] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[310] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[309] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[308] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[307] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[306] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[305] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[304] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[303] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[302] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[301] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[300] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[299] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[298] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[297] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[296] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[295] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[294] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[293] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[292] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[291] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[290] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[289] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[288] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[287] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[286] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[285] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[284] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[283] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[282] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[281] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[280] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[279] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[278] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[277] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[276] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[275] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[274] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[273] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[272] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[271] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[270] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[269] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[268] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[267] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[266] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[265] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[264] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[263] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[262] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[261] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[260] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[259] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[258] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[257] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[256] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[255] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[254] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[253] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[252] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[251] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[250] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[249] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[248] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[247] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[246] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[245] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[244] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[243] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[242] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[241] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[240] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[239] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[238] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[237] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[236] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[235] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[234] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[233] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[232] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[231] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[230] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[229] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[228] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[227] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[226] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[225] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[224] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[223] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[222] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[221] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[220] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[219] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[218] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[217] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[216] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[215] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[214] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[213] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[212] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[211] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[210] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[209] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[208] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[207] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[206] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[205] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[204] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[203] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[202] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[201] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[200] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[199] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[198] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[197] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[196] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[195] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[194] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[193] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[192] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[191] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[190] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[189] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[188] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[187] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[186] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[185] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[184] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[183] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[182] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[181] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[180] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[179] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[178] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[177] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[176] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[175] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[174] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[173] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[172] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[171] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[170] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[169] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[168] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[167] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[166] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[165] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[164] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[163] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[162] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[161] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[160] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[159] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[158] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[157] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[156] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[155] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[154] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[153] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[152] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[151] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[150] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[149] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[148] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[147] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[146] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[145] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[144] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[143] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[142] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[141] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[140] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[139] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[138] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[137] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[136] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[135] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[134] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[133] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[132] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[131] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[130] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[129] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[128] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[127] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[126] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[125] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[124] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[123] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[122] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[121] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[120] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[119] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[118] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[117] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[116] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[115] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[114] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[113] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[112] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[111] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[110] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[109] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[108] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[107] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[106] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[105] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[104] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[103] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[102] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[101] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[100] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[99] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[98] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[97] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[96] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[95] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[94] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[93] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[92] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[91] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[90] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[89] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[88] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[87] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[86] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[85] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[84] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[83] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[82] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[81] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[80] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[79] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[78] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[77] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[76] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[75] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[74] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[73] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[72] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[71] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[70] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[69] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[68] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[67] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[66] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[65] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[64] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[63] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[62] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[61] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[60] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[59] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[58] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[57] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[56] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[55] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[54] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[53] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[52] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[51] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[50] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[49] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[48] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[47] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[46] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[45] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[44] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[43] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[42] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[41] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[40] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[39] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[38] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[37] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[36] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[35] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[34] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[33] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[32] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[31] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[30] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[29] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[28] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[27] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[26] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[25] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[24] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[23] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[22] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[21] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[20] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[19] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[18] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[17] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[16] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[15] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[14] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[13] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[12] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[11] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[10] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[9] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[8] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[7] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[6] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[5] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[4] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[3] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[2] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xipbypass[1] vdd_ldo_out_o ipbypass_g vdd_hv vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi119[6] n9 n6 n1 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi119[5] n9 n6 n1 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi119[4] n9 n6 n1 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi119[3] n9 n6 n1 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi119[2] n9 n6 n1 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Xi119[1] n9 n6 n1 vdd_hv ringpll__x22imc_ana_p144_mult1_2stack_width m=1
Mqn5[4] ipbypass_g pd_bp vssx vssx ntgmv W=180n L=120n M=1
Mqn5[3] ipbypass_g pd_bp vssx vssx ntgmv W=180n L=120n M=1
Mqn5[2] ipbypass_g pd_bp vssx vssx ntgmv W=180n L=120n M=1
Mqn5[1] ipbypass_g pd_bp vssx vssx ntgmv W=180n L=120n M=1
Mqn0[8] ibias_1u pd vssx vssx ntgmv W=180n L=120n M=1
Mqn0[7] ibias_1u pd vssx vssx ntgmv W=180n L=120n M=1
Mqn0[6] ibias_1u pd vssx vssx ntgmv W=180n L=120n M=1
Mqn0[5] ibias_1u pd vssx vssx ntgmv W=180n L=120n M=1
Mqn0[4] ibias_1u pd vssx vssx ntgmv W=180n L=120n M=1
Mqn0[3] ibias_1u pd vssx vssx ntgmv W=180n L=120n M=1
Mqn0[2] ibias_1u pd vssx vssx ntgmv W=180n L=120n M=1
Mqn0[1] ibias_1u pd vssx vssx ntgmv W=180n L=120n M=1
Mqn1[2] feedback pd vssx vssx ntgmv W=180n L=120n M=1
Mqn1[1] feedback pd vssx vssx ntgmv W=180n L=120n M=1
Mqn2[4] out2p pd_bp vssx vssx ntgmv W=180n L=120n M=1
Mqn2[3] out2p pd_bp vssx vssx ntgmv W=180n L=120n M=1
Mqn2[2] out2p pd_bp vssx vssx ntgmv W=180n L=120n M=1
Mqn2[1] out2p pd_bp vssx vssx ntgmv W=180n L=120n M=1
Mqn4[4] n9 d_imess_en_i vssx vssx ntgmv W=180n L=120n M=1
Mqn4[3] n9 d_imess_en_i vssx vssx ntgmv W=180n L=120n M=1
Mqn4[2] n9 d_imess_en_i vssx vssx ntgmv W=180n L=120n M=1
Mqn4[1] n9 d_imess_en_i vssx vssx ntgmv W=180n L=120n M=1
Mqn3[4] res pd_o vssx vssx ntgmv W=180n L=120n M=1
Mqn3[3] res pd_o vssx vssx ntgmv W=180n L=120n M=1
Mqn3[2] res pd_o vssx vssx ntgmv W=180n L=120n M=1
Mqn3[1] res pd_o vssx vssx ntgmv W=180n L=120n M=1
Xi233 vssx nsource2 d_startpulse_i vdd_hv vssx ringpll__x22heldo_tgate_logic_tg
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22lpldo_pulsegen_2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22lpldo_pulsegen_2 dmfix_out clkin dmfix_in vccxx vssx
* .PININFO clkin:I dmfix_in:I vccxx:I vssx:I dmfix_out:O
Xnand1 cnt_b vccxx vssx b6_b b7_b ringpll__xb15nand02xl1n03x5
Xnand0 n4 vccxx vssx dmfix_in pulse ringpll__xb15nand02xl1n03x5
Xfan00 pulse_b vccxx vssx cnt vssx vssx dmfix_in vssx ringpll__xb15fan07bxl1n08x5
Xibit6 b6 b5 dmfix_in vccxx vssx ringpll__x22lpldo_cnt_bit
Xibit3 b3 b2 dmfix_in vccxx vssx ringpll__x22lpldo_cnt_bit
Xibit4 b4 b3 dmfix_in vccxx vssx ringpll__x22lpldo_cnt_bit
Xibit7 b7 b6 dmfix_in vccxx vssx ringpll__x22lpldo_cnt_bit
Xibit2 b2 b1 dmfix_in vccxx vssx ringpll__x22lpldo_cnt_bit
Xibit1 b1 clkin dmfix_in vccxx vssx ringpll__x22lpldo_cnt_bit
Xibit5 b5 b4 dmfix_in vccxx vssx ringpll__x22lpldo_cnt_bit
Xinv01 cnt vccxx vssx cnt_b ringpll__xb15inv000xl1n04x5
Xinv04 b6_b vccxx vssx b6 ringpll__xb15inv000xl1n04x5
Xinv03 b7_b vccxx vssx b7 ringpll__xb15inv000xl1n04x5
Xinv02 pulse vccxx vssx pulse_b ringpll__xb15inv000xl1n04x5
Xinv00 dmfix_out vccxx vssx n4 ringpll__xb15inv000xl1n04x5
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22ldo_dftamp
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22ldo_dftamp ampout ampin enable vcc_nom vssx
* .PININFO ampin:I enable:I vcc_nom:I vssx:I ampout:O
Xipinn[4] ampout ampout psource vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipinn[3] ampout ampout psource vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipinn[2] ampout ampout psource vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipinn[1] ampout ampout psource vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipldn[4] noutn noutn vcc_nom vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipldn[3] noutn noutn vcc_nom vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipldn[2] noutn noutn vcc_nom vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipldn[1] noutn noutn vcc_nom vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipldp[4] ampout noutn vcc_nom vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipldp[3] ampout noutn vcc_nom vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipldp[2] ampout noutn vcc_nom vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipldp[1] ampout noutn vcc_nom vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipinp[4] poutn ampin psource vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipinp[3] poutn ampin psource vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipinp[2] poutn ampin psource vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xipinp[1] poutn ampin psource vcc_nom ringpll__x22imc_p_p144_mult2_2stack m=1
Xinres nsource nres vssx ringpll__x22heldo_res_10k
Xipres pres psource vssx ringpll__x22heldo_res_10k
Mip_dummy[4] psource vcc_nom vcc_nom vcc_nom p W=180n L=40n M=1
Mip_dummy[3] psource vcc_nom vcc_nom vcc_nom p W=180n L=40n M=1
Mip_dummy[2] psource vcc_nom vcc_nom vcc_nom p W=180n L=40n M=1
Mip_dummy[1] psource vcc_nom vcc_nom vcc_nom p W=180n L=40n M=1
Min_dummy[4] nsource vssx vssx vssx n W=180n L=40n M=1
Min_dummy[3] nsource vssx vssx vssx n W=180n L=40n M=1
Min_dummy[2] nsource vssx vssx vssx n W=180n L=40n M=1
Min_dummy[1] nsource vssx vssx vssx n W=180n L=40n M=1
Xininn[4] ampout ampout nsource vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xininn[3] ampout ampout nsource vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xininn[2] ampout ampout nsource vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xininn[1] ampout ampout nsource vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xininp[4] noutn ampin nsource vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xininp[3] noutn ampin nsource vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xininp[2] noutn ampin nsource vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xininp[1] noutn ampin nsource vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xinldn[4] poutn poutn vssx vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xinldn[3] poutn poutn vssx vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xinldn[2] poutn poutn vssx vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xinldn[1] poutn poutn vssx vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xinldp[4] ampout poutn vssx vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xinldp[3] ampout poutn vssx vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xinldp[2] ampout poutn vssx vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Xinldp[1] ampout poutn vssx vssx ringpll__x22imc_n_n144_mult2_2stack m=1
Minen[4] nres en_n vssx vssx ntgmv W=180n L=120n M=1
Minen[3] nres en_n vssx vssx ntgmv W=180n L=120n M=1
Minen[2] nres en_n vssx vssx ntgmv W=180n L=120n M=1
Minen[1] nres en_n vssx vssx ntgmv W=180n L=120n M=1
Mipen[4] pres en_p vcc_nom vcc_nom ptgmv W=180n L=120n M=1
Mipen[3] pres en_p vcc_nom vcc_nom ptgmv W=180n L=120n M=1
Mipen[2] pres en_p vcc_nom vcc_nom ptgmv W=180n L=120n M=1
Mipen[1] pres en_p vcc_nom vcc_nom ptgmv W=180n L=120n M=1
Xinv00 en_n vcc_nom vssx en_p ringpll__xb15inv000xu1n02x5
Xinv04 en_p vcc_nom vssx enable ringpll__xb15inv000xu1n02x5
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_anamux8
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_anamux8 aout ain0 ain1 ain2 ain3 ain4 ain5 ain6 ain7 sel[2] sel[1] sel[0] vccxx vssx
* .PININFO ain0:I ain1:I ain2:I ain3:I ain4:I ain5:I ain6:I ain7:I sel[2]:I sel[1]:I sel[0]:I vccxx:I vssx:I aout:O
Ximux[7] aout ain7 dec[7] vccxx vssx ringpll__pll_anamux
Ximux[6] aout ain6 dec[6] vccxx vssx ringpll__pll_anamux
Ximux[5] aout ain5 dec[5] vccxx vssx ringpll__pll_anamux
Ximux[4] aout ain4 dec[4] vccxx vssx ringpll__pll_anamux
Ximux[3] aout ain3 dec[3] vccxx vssx ringpll__pll_anamux
Ximux[2] aout ain2 dec[2] vccxx vssx ringpll__pll_anamux
Ximux[1] aout ain1 dec[1] vccxx vssx ringpll__pll_anamux
Ximux[0] aout ain0 dec[0] vccxx vssx ringpll__pll_anamux
Xidec dec[7] dec[6] dec[5] dec[4] dec[3] dec[2] dec[1] dec[0] sel[2] sel[1] sel[0] vccxx vssx ringpll__pll_3to8dec
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_cclkdiv
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_cclkdiv adcensync ckoutang adcen ckph1 ckx1clk clkdiv[1] clkdiv[0] rst_b vccxx vssx
* .PININFO adcen:I ckph1:I ckx1clk:I clkdiv[1]:I clkdiv[0]:I rst_b:I vccxx:I vssx:I adcensync:O ckoutang:O
Xfmy20 ckph1_dly2 adcen n4 vccxx vccxx vccxx vssx ringpll__b15fmy200al1n04x5 m=1
Xcbf02 ckmuxout ckmuxout_dly vccxx vssx ringpll__b15cbf000al1n06x5 m=1
Xcbf00 ckph1 ckph1_dly1 vccxx vssx ringpll__b15cbf000al1n04x5 m=1
Xcbf01 ckph1_dly1 ckph1_dly2 vccxx vssx ringpll__b15cbf000al1n04x5 m=1
Xi1 ckdiv2 ckx1clk rst_b vccxx vssx ringpll__adc_clkdivprim
Xi4 ckdiv8 ckdiv4 rst_b vccxx vssx ringpll__adc_clkdivprim
Xi3 ckdiv4 ckdiv2 rst_b vccxx vssx ringpll__adc_clkdivprim
Xi5 ckdiv16 ckdiv8 rst_b vccxx vssx ringpll__adc_clkdivprim
Xcbf03 ckmuxout_dly ckoutang vccxx vssx ringpll__b15cbf000al1n08x5 m=1
Xbfn01 n4 adcensync vccxx vssx ringpll__b15bfn000al1n08x5 m=1
Xmbc00 ckdiv2 ckdiv4 ckdiv8 ckdiv16 ckmuxout clkdiv[0] clkdiv[1] vccxx vssx ringpll__b15mbc024el1n08x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    cpafdivtop
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__cpafdivtop clkout clkin rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 rst vccx vssx
* .PININFO clkin:I rat0p5:I rat[9]:I rat[8]:I rat[7]:I rat[6]:I rat[5]:I rat[4]:I rat[3]:I rat[2]:I rat[1]:I rat[0]:I rst:I vccx:I vssx:I clkout:O
Xidivcore clkout cueh rstd clkmidb rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 rst vccx vssx ringpll__cpafdivcore
Xiphdel clkmidb clkin cueh rstd vccx vssx ringpll__cpaclkphdelana
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    cpafdivtop_pllclk
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__cpafdivtop_pllclk clkout clkin rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 rst vccx vssx
* .PININFO clkin:I rat0p5:I rat[9]:I rat[8]:I rat[7]:I rat[6]:I rat[5]:I rat[4]:I rat[3]:I rat[2]:I rat[1]:I rat[0]:I rst:I vccx:I vssx:I clkout:O
Xiphdel clkmidb clkin cueh rstd vccx vssx ringpll__cpaclkphdelana
Xidivcore clkout cueh rstd clkmidb rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 rst vccx vssx ringpll__cpafdivcore_pllclk
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_lf
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_lf vctl rtrim[4] rtrim[3] rtrim[2] rtrim[1] rtrim[0] vccpll vcp vctl0 vssx
* .PININFO rtrim[4]:I rtrim[3]:I rtrim[2]:I rtrim[1]:I rtrim[0]:I vccpll:I vcp:I vctl0:I vssx:I vctl:O
Xi44 vctl net14 vccpll ringpll__res_tfr_pcell_133
Xir3 vcp vctl vccpll ringpll__res_tfr_pcell_133
Xi45 net14 vctl vccpll ringpll__res_tfr_pcell_133
Xi6 vctl vcp rtrim[4] vccpll vssx ringpll__pll_lfmux
Xic2 vcp vccpll vssx ringpll__mfc_s2p_pcell_134
Xic3 vctl vccpll vssx ringpll__mfc_s2p_pcell_135
Xilfdef rtrim_i[3] rtrim_i[2] rtrim_i[1] rtrim_i[0] rtrim[3] rtrim[2] rtrim[1] rtrim[0] vccpll vssx ringpll__pll_lfdef
Xires rtrim_i[3] rtrim_i[2] rtrim_i[1] rtrim_i[0] vccpll vcp vctl0 vssx ringpll__pll_lf_res
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_viewmux32
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_viewmux32 viewout en v0 v1 v2 v3 v4 v5 v6 v7 v8 v9 v10 v11 v12 v13 v14 v15 v16 v17 v18 v19 v20 v21 v22 v23 v24 v25 v26 v27 v28 v29 v30 v31 vccpll viewsel[4] viewsel[3] viewsel[2] viewsel[1] viewsel[0] vssx
* .PININFO en:I v0:I v1:I v2:I v3:I v4:I v5:I v6:I v7:I v8:I v9:I v10:I v11:I v12:I v13:I v14:I v15:I v16:I v17:I v18:I v19:I v20:I v21:I v22:I v23:I
* .PININFO v24:I v25:I v26:I v27:I v28:I v29:I v30:I v31:I vccpll:I viewsel[4]:I viewsel[3]:I viewsel[2]:I viewsel[1]:I viewsel[0]:I vssx:I viewout:O
Xbfm20 en eni vccpll vssx ringpll__b15bfm201al1n04x5 m=1
Xmbn02 n5 n6 n7 viewsel[4] vccpll vssx ringpll__b15mbn022al1n04x5 m=1
Xmbn01 n3 n4 n6 viewsel[3] vccpll vssx ringpll__b15mbn022al1n04x5 m=1
Xmbn00 n1 n2 n5 viewsel[3] vccpll vssx ringpll__b15mbn022al1n04x5 m=1
Ximx80 n4 viewsel[2] viewsel[1] viewsel[0] v0 v1 v2 v3 v4 v5 v6 v7 vccpll vssx ringpll__pll_viewmux8
Ximx81 n3 viewsel[2] viewsel[1] viewsel[0] v8 v9 v10 v11 v12 v13 v14 v15 vccpll vssx ringpll__pll_viewmux8
Ximx82 n2 viewsel[2] viewsel[1] viewsel[0] v16 v17 v18 v19 v20 v21 v22 v23 vccpll vssx ringpll__pll_viewmux8
Ximx83 n1 viewsel[2] viewsel[1] viewsel[0] v24 v25 v26 v27 v28 v29 v30 v31 vccpll vssx ringpll__pll_viewmux8
Xclb01 n7 viewout eni vccpll vssx ringpll__b15clb0a2al1n12x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_lpf
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_lpf lp_in lp_out res_bypass vccxx vssx
* .PININFO res_bypass:I vccxx:I vssx:I lp_in:B lp_out:B
Xi6 lp_out lp_in vssx ringpll__x22heldo_lpf_topres
Xipass4 lp_in lp_out res_bypass vccxx vssx ringpll__x22heldo_tgate_logic
Xilpfcap2 lp_out vssx ringpll__mfc_s2g_pcell_11
Xi18 lp_out vssx ringpll__mfc_s2g_pcell_12
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll1_dcatop
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll1_dcatop clkout cb[1] cb[0] clkin ctrl[5] ctrl[4] ctrl[3] ctrl[2] ctrl[1] ctrl[0] vcc_nom vssx
* .PININFO cb[1]:I cb[0]:I clkin:I ctrl[5]:I ctrl[4]:I ctrl[3]:I ctrl[2]:I ctrl[1]:I ctrl[0]:I vcc_nom:I vssx:I clkout:O
Xickbls_x9pllcoldcatop clkout cb[1] cb[0] clkin ctrl[5] ctrl[4] ctrl[3] ctrl[2] ctrl[1] ctrl[0] vcc_nom vssx ringpll__pll_pllcoldcatop
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_refresdiv_1v_to_0p6v
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_refresdiv_1v_to_0p6v tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 en_1p24v pon vcc_hv vssx
* .PININFO en_1p24v:I pon:I vcc_hv:I vssx:I tap0:B tap1:B tap2:B tap3:B tap4:B tap5:B tap6:B tap7:B tap8:B tap9:B tap10:B tap11:B tap12:B tap13:B
* .PININFO tap14:B tap15:B
Miplvm[10] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[9] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[8] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[7] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[6] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[5] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[4] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[3] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[2] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[1] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Xi36 resm3 resm2 vssx ringpll__x22heldo_res_10k
Xi38 resn9 respwrgt vssx ringpll__x22heldo_res_10k
Xi39 resn3 resn4 vssx ringpll__x22heldo_res_10k
Xresp1 resm1 v0p85 vssx ringpll__x22heldo_res_10k
Xresp2 resm2 resm1 vssx ringpll__x22heldo_res_10k
Xi37 vcc_hv resm3 vssx ringpll__x22heldo_res_10k
Xres4 tap0 resn2 vssx ringpll__x22heldo_res_10k
Xres3 resn2 resn3 vssx ringpll__x22heldo_res_10k
Xres2 resn1 tap15 vssx ringpll__x22heldo_res_10k
Xres1 v0p85 resn1 vssx ringpll__x22heldo_res_10k
Xres21 resn4 resn5 vssx ringpll__x22heldo_res_10k
Xres22 resn5 resn6 vssx ringpll__x22heldo_res_10k
Xres23 resn6 resn7 vssx ringpll__x22heldo_res_10k
Xres24 resn7 resn8 vssx ringpll__x22heldo_res_10k
Xres25 resn8 resn9 vssx ringpll__x22heldo_res_10k
Mqn0[10] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[9] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[8] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[7] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[6] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[5] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[4] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[3] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[2] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[1] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Xires19 tap1 tap0 vssx ringpll__x22heldo_res_1p6k
Xires16 tap4 tap3 vssx ringpll__x22heldo_res_1p6k
Xires17 tap3 tap2 vssx ringpll__x22heldo_res_1p6k
Xires13 tap7 tap6 vssx ringpll__x22heldo_res_1p6k
Xires14 tap6 tap5 vssx ringpll__x22heldo_res_1p6k
Xires10 tap10 tap9 vssx ringpll__x22heldo_res_1p6k
Xires11 tap9 tap8 vssx ringpll__x22heldo_res_1p6k
Xires7 tap13 tap12 vssx ringpll__x22heldo_res_1p6k
Xires8 tap12 tap11 vssx ringpll__x22heldo_res_1p6k
Xires18 tap2 tap1 vssx ringpll__x22heldo_res_1p6k
Xires5 tap15 tap14 vssx ringpll__x22heldo_res_1p6k
Xires6 tap14 tap13 vssx ringpll__x22heldo_res_1p6k
Xires9 tap11 tap10 vssx ringpll__x22heldo_res_1p6k
Xires12 tap8 tap7 vssx ringpll__x22heldo_res_1p6k
Xires15 tap5 tap4 vssx ringpll__x22heldo_res_1p6k
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_refresdiv
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_refresdiv tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 en_1p24v pon vcc_hv vssx
* .PININFO en_1p24v:I pon:I vcc_hv:I vssx:I tap0:B tap1:B tap2:B tap3:B tap4:B tap5:B tap6:B tap7:B tap8:B tap9:B tap10:B tap11:B tap12:B tap13:B
* .PININFO tap14:B tap15:B
Miplvm[10] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[9] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[8] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[7] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[6] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[5] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[4] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[3] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[2] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Miplvm[1] resm2 en_1p24v vcc_hv vcc_hv ptgmv W=180n L=120n M=1
Xi36 resm3 resm2 vssx ringpll__x22heldo_res_10k
Xi38 resn9 respwrgt vssx ringpll__x22heldo_res_10k
Xi39 tap0 resn4 vssx ringpll__x22heldo_res_10k
Xresp1 resm1 v0p85 vssx ringpll__x22heldo_res_10k
Xresp2 resm2 resm1 vssx ringpll__x22heldo_res_10k
Xi37 vcc_hv resm3 vssx ringpll__x22heldo_res_10k
Xres4 resn3 tap15 vssx ringpll__x22heldo_res_10k
Xres3 resn2 resn3 vssx ringpll__x22heldo_res_10k
Xres2 resn1 resn2 vssx ringpll__x22heldo_res_10k
Xres1 v0p85 resn1 vssx ringpll__x22heldo_res_10k
Xres21 resn4 resn5 vssx ringpll__x22heldo_res_10k
Xres22 resn5 resn6 vssx ringpll__x22heldo_res_10k
Xres23 resn6 resn7 vssx ringpll__x22heldo_res_10k
Xres24 resn7 resn8 vssx ringpll__x22heldo_res_10k
Xres25 resn8 resn9 vssx ringpll__x22heldo_res_10k
Mqn0[10] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[9] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[8] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[7] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[6] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[5] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[4] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[3] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[2] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Mqn0[1] respwrgt pon vssx vssx ntgmv W=180n L=120n M=1
Xires19 tap1 tap0 vssx ringpll__x22heldo_res_1p6k
Xires16 tap4 tap3 vssx ringpll__x22heldo_res_1p6k
Xires17 tap3 tap2 vssx ringpll__x22heldo_res_1p6k
Xires13 tap7 tap6 vssx ringpll__x22heldo_res_1p6k
Xires14 tap6 tap5 vssx ringpll__x22heldo_res_1p6k
Xires10 tap10 tap9 vssx ringpll__x22heldo_res_1p6k
Xires11 tap9 tap8 vssx ringpll__x22heldo_res_1p6k
Xires7 tap13 tap12 vssx ringpll__x22heldo_res_1p6k
Xires8 tap12 tap11 vssx ringpll__x22heldo_res_1p6k
Xires18 tap2 tap1 vssx ringpll__x22heldo_res_1p6k
Xires5 tap15 tap14 vssx ringpll__x22heldo_res_1p6k
Xires6 tap14 tap13 vssx ringpll__x22heldo_res_1p6k
Xires9 tap11 tap10 vssx ringpll__x22heldo_res_1p6k
Xires12 tap8 tap7 vssx ringpll__x22heldo_res_1p6k
Xires15 tap5 tap4 vssx ringpll__x22heldo_res_1p6k
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22ldo_pll_40k_res
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22ldo_pll_40k_res porta portb vssx
* .PININFO vssx:I porta:B portb:B
Xires3 mid3 mid2 vssx ringpll__x22heldo_res_10k
Xires2 mid1 mid2 vssx ringpll__x22heldo_res_10k
Xires4 portb mid3 vssx ringpll__x22heldo_res_10k
Xires1 porta mid1 vssx ringpll__x22heldo_res_10k
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_resdiv_0p85
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_resdiv_0p85 tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 vccpll vssx
* .PININFO vccpll:I vssx:I tap0:O tap1:O tap2:O tap3:O tap4:O tap5:O tap6:O tap7:O tap8:O tap9:O tap10:O tap11:O tap12:O tap13:O tap14:O tap15:O
Xres26 resn9 resn_10 vssx ringpll__x22heldo_res_10k
Xi46 resn_10 vssx vssx ringpll__x22heldo_res_10k
Xres2 resn1 tap0 vssx ringpll__x22heldo_res_10k
Xres1 vccpll resn1 vssx ringpll__x22heldo_res_10k
Xres21 resn4 resn5 vssx ringpll__x22heldo_res_10k
Xres22 resn5 resn6 vssx ringpll__x22heldo_res_10k
Xres23 resn6 resn7 vssx ringpll__x22heldo_res_10k
Xres24 resn7 resn8 vssx ringpll__x22heldo_res_10k
Xres25 resn8 resn9 vssx ringpll__x22heldo_res_10k
Xires12 tap7 tap8 vssx ringpll__x22heldo_res_1p6k
Xires11 tap6 tap7 vssx ringpll__x22heldo_res_1p6k
Xires20 tap15 resn4 vssx ringpll__x22heldo_res_1p6k
Xires18 tap13 tap14 vssx ringpll__x22heldo_res_1p6k
Xires17 tap12 tap13 vssx ringpll__x22heldo_res_1p6k
Xires15 tap10 tap11 vssx ringpll__x22heldo_res_1p6k
Xires14 tap9 tap10 vssx ringpll__x22heldo_res_1p6k
Xires9 tap4 tap5 vssx ringpll__x22heldo_res_1p6k
Xires8 tap3 tap4 vssx ringpll__x22heldo_res_1p6k
Xires6 tap1 tap2 vssx ringpll__x22heldo_res_1p6k
Xires5 tap0 tap1 vssx ringpll__x22heldo_res_1p6k
Xires10 tap5 tap6 vssx ringpll__x22heldo_res_1p6k
Xires19 tap14 tap15 vssx ringpll__x22heldo_res_1p6k
Xires16 tap11 tap12 vssx ringpll__x22heldo_res_1p6k
Xires13 tap8 tap9 vssx ringpll__x22heldo_res_1p6k
Xires7 tap2 tap3 vssx ringpll__x22heldo_res_1p6k
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22ldo_pll_20k_res
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22ldo_pll_20k_res porta portb vssx
* .PININFO vssx:I porta:B portb:B
Xires2 portb mid1 vssx ringpll__x22heldo_res_10k
Xires1 porta mid1 vssx ringpll__x22heldo_res_10k
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljplldac_res
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljplldac_res bot nwl tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 top
* .PININFO bot:B nwl:B tap0:B tap1:B tap2:B tap3:B tap4:B tap5:B tap6:B tap7:B tap8:B tap9:B tap10:B tap11:B tap12:B tap13:B tap14:B tap15:B top:B
Xires12 tap7 tap8 nwl ringpll__pllx22ljplldac_res_cell
Xires11 tap6 tap7 nwl ringpll__pllx22ljplldac_res_cell
Xi48 top tap0 nwl ringpll__pllx22ljplldac_res_cell
Xi47 tap15 bot nwl ringpll__pllx22ljplldac_res_cell
Xires18 tap13 tap14 nwl ringpll__pllx22ljplldac_res_cell
Xires17 tap12 tap13 nwl ringpll__pllx22ljplldac_res_cell
Xires15 tap10 tap11 nwl ringpll__pllx22ljplldac_res_cell
Xires14 tap9 tap10 nwl ringpll__pllx22ljplldac_res_cell
Xires9 tap4 tap5 nwl ringpll__pllx22ljplldac_res_cell
Xires8 tap3 tap4 nwl ringpll__pllx22ljplldac_res_cell
Xires6 tap1 tap2 nwl ringpll__pllx22ljplldac_res_cell
Xires5 tap0 tap1 nwl ringpll__pllx22ljplldac_res_cell
Xires10 tap5 tap6 nwl ringpll__pllx22ljplldac_res_cell
Xires19 tap14 tap15 nwl ringpll__pllx22ljplldac_res_cell
Xires16 tap11 tap12 nwl ringpll__pllx22ljplldac_res_cell
Xires13 tap8 tap9 nwl ringpll__pllx22ljplldac_res_cell
Xires7 tap2 tap3 nwl ringpll__pllx22ljplldac_res_cell
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ljpll_sip
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ljpll_sip clkrefxxh reset_b_nnnnh plldistpwrgoodnnnnh bypassnnnnh rationnnnh[9] rationnnnh[8] rationnnnh[7] rationnnnh[6] rationnnnh[5] rationnnnh[4] rationnnnh[3] rationnnnh[2] rationnnnh[1] rationnnnh[0] fractionnnnnh[23] fractionnnnnh[22] fractionnnnnh[21] fractionnnnnh[20] fractionnnnnh[19] fractionnnnnh[18] fractionnnnnh[17] fractionnnnnh[16] fractionnnnnh[15] fractionnnnnh[14] fractionnnnnh[13] fractionnnnnh[12] fractionnnnnh[11] fractionnnnnh[10] fractionnnnnh[9] fractionnnnnh[8] fractionnnnnh[7] fractionnnnnh[6] fractionnnnnh[5] fractionnnnnh[4] fractionnnnnh[3] fractionnnnnh[2] fractionnnnnh[1] fractionnnnnh[0] pll_fbgen__clkfbmxh pll_core__pfdlockrstnnnnh view_adc__dig_out[9] view_adc__dig_out[8] view_adc__dig_out[7] view_adc__dig_out[6] view_adc__dig_out[5] view_adc__dig_out[4] view_adc__dig_out[3] view_adc__dig_out[2] view_adc__dig_out[1] view_adc__dig_out[0] view_adc__done reset_sync__bypassxxnnnl reset_sync__reset_b_xxnnnl reset_sync__bypassenxxnnnl dfx__powergood dfx__reset_b dfx__viewdigennnnnh[1] dfx__viewdigennnnnh[0] dfx__viewanaennnnnh[1] dfx__viewanaennnnnh[0] dfx__viewselnnnnh[9] dfx__viewselnnnnh[8] dfx__viewselnnnnh[7] dfx__viewselnnnnh[6] dfx__viewselnnnnh[5] dfx__viewselnnnnh[4] dfx__viewselnnnnh[3] dfx__viewselnnnnh[2] dfx__viewselnnnnh[1] dfx__viewselnnnnh[0] view_mux__viewoutnnnnh[1] view_mux__viewoutnnnnh[0] ssc__directionmxh mash__ratiomxh[9] mash__ratiomxh[8] mash__ratiomxh[7] mash__ratiomxh[6] mash__ratiomxh[5] mash__ratiomxh[4] mash__ratiomxh[3] mash__ratiomxh[2] mash__ratiomxh[1] mash__ratiomxh[0] mash__halfintmxh idv_fub__idvgateennh idv__rdacctlth[3] idv__rdacctlth[2] idv__rdacctlth[1] idv__rdacctlth[0] idv__pgctlth[3] idv__pgctlth[2] idv__pgctlth[1] idv__pgctlth[0] idv__cbctlth[2] idv__cbctlth[1] idv__cbctlth[0] startup_gen__vctlrdacenxxh startup_gen__pfdenxxh vctl_trim_fsm__vctlrdacshortxxh earlylockxxnnnh lockxxnnnl tap_in[206] tap_in[205] tap_in[204] tap_in[203] tap_in[202] tap_in[201] tap_in[200] tap_in[199] tap_in[198] tap_in[197] tap_in[196] tap_in[195] tap_in[194] tap_in[193] tap_in[192] tap_in[191] tap_in[190] tap_in[189] tap_in[188] tap_in[187] tap_in[186] tap_in[185] tap_in[184] tap_in[183] tap_in[182] tap_in[181] tap_in[180] tap_in[179] tap_in[178] tap_in[177] tap_in[176] tap_in[175] tap_in[174] tap_in[173] tap_in[172] tap_in[171] tap_in[170] tap_in[169] tap_in[168] tap_in[167] tap_in[166] tap_in[165] tap_in[164] tap_in[163] tap_in[162] tap_in[161] tap_in[160] tap_in[159] tap_in[158] tap_in[157] tap_in[156] tap_in[155] tap_in[154] tap_in[153] tap_in[152] tap_in[151] tap_in[150] tap_in[149] tap_in[148] tap_in[147] tap_in[146] tap_in[145] tap_in[144] tap_in[143] tap_in[142] tap_in[141] tap_in[140] tap_in[139] tap_in[138] tap_in[137] tap_in[136] tap_in[135] tap_in[134] tap_in[133] tap_in[132] tap_in[131] tap_in[130] tap_in[129] tap_in[128] tap_in[127] tap_in[126] tap_in[125] tap_in[124] tap_in[123] tap_in[122] tap_in[121] tap_in[120] tap_in[119] tap_in[118] tap_in[117] tap_in[116] tap_in[115] tap_in[114] tap_in[113] tap_in[112] tap_in[111] tap_in[110] tap_in[109] tap_in[108] tap_in[107] tap_in[106] tap_in[105] tap_in[104] tap_in[103] tap_in[102] tap_in[101] tap_in[100] tap_in[99] tap_in[98] tap_in[97] tap_in[96] tap_in[95] tap_in[94] tap_in[93] tap_in[92] tap_in[91] tap_in[90] tap_in[89] tap_in[88] tap_in[87] tap_in[86] tap_in[85] tap_in[84] tap_in[83] tap_in[82] tap_in[81] tap_in[80] tap_in[79] tap_in[78] tap_in[77] tap_in[76] tap_in[75] tap_in[74] tap_in[73] tap_in[72] tap_in[71] tap_in[70] tap_in[69] tap_in[68] tap_in[67] tap_in[66] tap_in[65] tap_in[64] tap_in[63] tap_in[62] tap_in[61] tap_in[60] tap_in[59] tap_in[58] tap_in[57] tap_in[56] tap_in[55] tap_in[54] tap_in[53] tap_in[52] tap_in[51] tap_in[50] tap_in[49] tap_in[48] tap_in[47] tap_in[46] tap_in[45] tap_in[44] tap_in[43] tap_in[42] tap_in[41] tap_in[40] tap_in[39] tap_in[38] tap_in[37] tap_in[36] tap_in[35] tap_in[34] tap_in[33] tap_in[32] tap_in[31] tap_in[30] tap_in[29] tap_in[28] tap_in[27] tap_in[26] tap_in[25] tap_in[24] tap_in[23] tap_in[22] tap_in[21] tap_in[20] tap_in[19] tap_in[18] tap_in[17] tap_in[16] tap_in[15] tap_in[14] tap_in[13] tap_in[12] tap_in[11] tap_in[10] tap_in[9] tap_in[8] tap_in[7] tap_in[6] tap_in[5] tap_in[4] tap_in[3] tap_in[2] tap_in[1] tap_in[0] tap_out[61] tap_out[60] tap_out[59] tap_out[58] tap_out[57] tap_out[56] tap_out[55] tap_out[54] tap_out[53] tap_out[52] tap_out[51] tap_out[50] tap_out[49] tap_out[48] tap_out[47] tap_out[46] tap_out[45] tap_out[44] tap_out[43] tap_out[42] tap_out[41] tap_out[40] tap_out[39] tap_out[38] tap_out[37] tap_out[36] tap_out[35] tap_out[34] tap_out[33] tap_out[32] tap_out[31] tap_out[30] tap_out[29] tap_out[28] tap_out[27] tap_out[26] tap_out[25] tap_out[24] tap_out[23] tap_out[22] tap_out[21] tap_out[20] tap_out[19] tap_out[18] tap_out[17] tap_out[16] tap_out[15] tap_out[14] tap_out[13] tap_out[12] tap_out[11] tap_out[10] tap_out[9] tap_out[8] tap_out[7] tap_out[6] tap_out[5] tap_out[4] tap_out[3] tap_out[2] tap_out[1] tap_out[0] clkidvih lock_detector__rawlockxxnnnl ssc_mod_dfx__clkmodmxh adc_ctl__startxxh adc_ctl__reset_bxxl dfx__adc_clkdiv[1] dfx__adc_clkdiv[0] dfx__adc_freeze dfx__adc_chop_en dfx__adc_use_vref dfx__adc_sel_in[2] dfx__adc_sel_in[1] dfx__adc_sel_in[0] dfx__tight_loop dfx__cp1_trim[4] dfx__cp1_trim[3] dfx__cp1_trim[2] dfx__cp1_trim[1] dfx__cp1_trim[0] dfx__cp2_trim[4] dfx__cp2_trim[3] dfx__cp2_trim[2] dfx__cp2_trim[1] dfx__cp2_trim[0] dfx__skadj_ctrl[4] dfx__skadj_ctrl[3] dfx__skadj_ctrl[2] dfx__skadj_ctrl[1] dfx__skadj_ctrl[0] dfx__lockthresh[3] dfx__lockthresh[2] dfx__lockthresh[1] dfx__lockthresh[0] dfx__dca_ctrl[5] dfx__dca_ctrl[4] dfx__dca_ctrl[3] dfx__dca_ctrl[2] dfx__dca_ctrl[1] dfx__dca_ctrl[0] dfx__dca_cb[1] dfx__dca_cb[0] tlctrl_sip__tightloopxxnnnh fz_tight_loopb fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] fz_dca_cb[1] fz_dca_cb[0] fz_dca_ctrl[5] fz_dca_ctrl[4] fz_dca_ctrl[3] fz_dca_ctrl[2] fz_dca_ctrl[1] fz_dca_ctrl[0] fz_lockcnt[2] fz_lockcnt[1] fz_lockcnt[0] fz_lockforce fz_lockstickyb fz_lockthresh[3] fz_lockthresh[2] fz_lockthresh[1] fz_lockthresh[0] fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] fz_cpnbias[1] fz_cpnbias[0] fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] fz_nopfdpwrgate fz_lpfclksel fz_pfddly[1] fz_pfddly[0] fz_spare[4] fz_spare[3] fz_spare[2] fz_spare[1] fz_spare[0] fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] fz_vcosel fz_vcotrim[10] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] fz_ldo_vinvoltsel[1] fz_ldo_vinvoltsel[0] fz_ldo_bypass fz_ldo_extrefsel fz_ldo_faststart fz_ldo_fbtrim[3] fz_ldo_fbtrim[2] fz_ldo_fbtrim[1] fz_ldo_fbtrim[0] fz_ldo_reftrim[3] fz_ldo_reftrim[2] fz_ldo_reftrim[1] fz_ldo_reftrim[0] fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] mash_order_plus_one ssc_cyc_to_peak_m1[8] ssc_cyc_to_peak_m1[7] ssc_cyc_to_peak_m1[6] ssc_cyc_to_peak_m1[5] ssc_cyc_to_peak_m1[4] ssc_cyc_to_peak_m1[3] ssc_cyc_to_peak_m1[2] ssc_cyc_to_peak_m1[1] ssc_cyc_to_peak_m1[0] ssc_en ssc_frac_step[23] ssc_frac_step[22] ssc_frac_step[21] ssc_frac_step[20] ssc_frac_step[19] ssc_frac_step[18] ssc_frac_step[17] ssc_frac_step[16] ssc_frac_step[15] ssc_frac_step[14] ssc_frac_step[13] ssc_frac_step[12] ssc_frac_step[11] ssc_frac_step[10] ssc_frac_step[9] ssc_frac_step[8] ssc_frac_step[7] ssc_frac_step[6] ssc_frac_step[5] ssc_frac_step[4] ssc_frac_step[3] ssc_frac_step[2] ssc_frac_step[1] ssc_frac_step[0] ldo_enable mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] vcodiv_ratio[1] vcodiv_ratio[0] zdiv0_ratio[9] zdiv0_ratio[8] zdiv0_ratio[7] zdiv0_ratio[6] zdiv0_ratio[5] zdiv0_ratio[4] zdiv0_ratio[3] zdiv0_ratio[2] zdiv0_ratio[1] zdiv0_ratio[0] zdiv0_ratio_p5 zdiv1_ratio[9] zdiv1_ratio[8] zdiv1_ratio[7] zdiv1_ratio[6] zdiv1_ratio[5] zdiv1_ratio[4] zdiv1_ratio[3] zdiv1_ratio[2] zdiv1_ratio[1] zdiv1_ratio[0] zdiv1_ratio_p5 idvdisable_bi idvfreqai idvfreqbi idvpulsei idvtclki idvtctrli idvtdi idvtresi idvdisable_bo idvfreqao idvfreqbo idvpulseo p61 idvtctrlo idvtdo idvtreso dfx__ldo_enable_a dfx__ta_ldo_hiz_debug dfx__ta_ldo_idq_debug dfx__ta_spare[4] dfx__ta_spare[3] dfx__ta_spare[2] dfx__ta_spare[1] dfx__ta_spare[0] dfx__fz_ldo_vinvoltsel_a[1] dfx__fz_ldo_vinvoltsel_a[0] dfx__fz_ldo_bypass_a dfx__fz_ldo_extrefsel_a dfx__fz_ldo_faststart_a dfx__fz_ldo_fbtrim_a[3] dfx__fz_ldo_fbtrim_a[2] dfx__fz_ldo_fbtrim_a[1] dfx__fz_ldo_fbtrim_a[0] dfx__fz_ldo_reftrim_a[3] dfx__fz_ldo_reftrim_a[2] dfx__fz_ldo_reftrim_a[1] dfx__fz_ldo_reftrim_a[0] dfx__mdiv_ratio_a[5] dfx__mdiv_ratio_a[4] dfx__mdiv_ratio_a[3] dfx__mdiv_ratio_a[2] dfx__mdiv_ratio_a[1] dfx__mdiv_ratio_a[0] dfx__vcodiv_ratio_a[1] dfx__vcodiv_ratio_a[0] dfx__zdiv0_ratio_a[9] dfx__zdiv0_ratio_a[8] dfx__zdiv0_ratio_a[7] dfx__zdiv0_ratio_a[6] dfx__zdiv0_ratio_a[5] dfx__zdiv0_ratio_a[4] dfx__zdiv0_ratio_a[3] dfx__zdiv0_ratio_a[2] dfx__zdiv0_ratio_a[1] dfx__zdiv0_ratio_a[0] dfx__zdiv0_ratio_p5_a dfx__zdiv1_ratio_a[9] dfx__zdiv1_ratio_a[8] dfx__zdiv1_ratio_a[7] dfx__zdiv1_ratio_a[6] dfx__zdiv1_ratio_a[5] dfx__zdiv1_ratio_a[4] dfx__zdiv1_ratio_a[3] dfx__zdiv1_ratio_a[2] dfx__zdiv1_ratio_a[1] dfx__zdiv1_ratio_a[0] dfx__zdiv1_ratio_p5_a dfx__cpnbias[1] dfx__cpnbias[0] dfx__fz_irefgen_a[4] dfx__fz_irefgen_a[3] dfx__fz_irefgen_a[2] dfx__fz_irefgen_a[1] dfx__fz_irefgen_a[0] dfx__fz_lpfclksel_a dfx__fz_nopfdpwrgate_a dfx__fz_pfd_pw_a[2] dfx__fz_pfd_pw_a[1] dfx__fz_pfd_pw_a[0] dfx__fz_pfddly_a[1] dfx__fz_pfddly_a[0] dfx__fz_spare_a[4] dfx__fz_spare_a[3] dfx__fz_spare_a[2] dfx__fz_spare_a[1] dfx__fz_spare_a[0] dfx__fz_startup_a[5] dfx__fz_startup_a[4] dfx__fz_startup_a[3] dfx__fz_startup_a[2] dfx__fz_startup_a[1] dfx__fz_startup_a[0] dfx__fz_vcosel_a dfx__fz_vcotrim_a[10] dfx__fz_vcotrim_a[9] dfx__fz_vcotrim_a[8] dfx__fz_vcotrim_a[7] dfx__fz_vcotrim_a[6] dfx__fz_vcotrim_a[5] dfx__fz_vcotrim_a[4] dfx__fz_vcotrim_a[3] dfx__fz_vcotrim_a[2] dfx__fz_vcotrim_a[1] dfx__fz_vcotrim_a[0] global_align__gateclkdistxxnnnl idfx_fscan_sdi[2] idfx_fscan_sdi[1] idfx_fscan_sdi[0] idfx_fscan_mode idfx_fscan_shiften idfx_fscan_rstbypen idfx_fscan_byprstb idfx_fscan_clkungate odfx_fscan_sdo[2] odfx_fscan_sdo[1] odfx_fscan_sdo[0] test_si1 test_so3 test_so2 test_so1 test_sei vdd vssx p_aps0 p_aps1 p_abuf0 p_abuf1 p_abuf2 p_abuf3 p_abuf4 p_abuf5 p_abuf6 p_abuf7 p_abuf8 p_abuf9 p_abuf10 p_abuf11 p_abuf12 p_abuf13 p_abuf14 p_abuf15 p_abuf16 p_abuf17 p_abuf18 p_abuf19 p_abuf20 p_abuf21 p_abuf22 p_abuf23 p_abuf24 p_abuf25 p0 p1 p2 p3 p4 p5 p6 p8 p12 p_abuf41 p39 p40 p44 p45 p50 p51 p_abuf26 p9 p_abuf44 p62 p_abuf46 p63 p_abuf47 p64 p13 p14
* .PININFO bypassnnnnh:I clkidvih:I clkrefxxh:I fractionnnnnh[23]:I fractionnnnnh[22]:I fractionnnnnh[21]:I fractionnnnnh[20]:I fractionnnnnh[19]:I
* .PININFO fractionnnnnh[18]:I fractionnnnnh[17]:I fractionnnnnh[16]:I fractionnnnnh[15]:I fractionnnnnh[14]:I fractionnnnnh[13]:I fractionnnnnh[12]:I
* .PININFO fractionnnnnh[11]:I fractionnnnnh[10]:I fractionnnnnh[9]:I fractionnnnnh[8]:I fractionnnnnh[7]:I fractionnnnnh[6]:I fractionnnnnh[5]:I
* .PININFO fractionnnnnh[4]:I fractionnnnnh[3]:I fractionnnnnh[2]:I fractionnnnnh[1]:I fractionnnnnh[0]:I fz_cp1trim[4]:I fz_cp1trim[3]:I
* .PININFO fz_cp1trim[2]:I fz_cp1trim[1]:I fz_cp1trim[0]:I fz_cp2trim[4]:I fz_cp2trim[3]:I fz_cp2trim[2]:I fz_cp2trim[1]:I fz_cp2trim[0]:I
* .PININFO fz_cpnbias[1]:I fz_cpnbias[0]:I fz_dca_cb[1]:I fz_dca_cb[0]:I fz_dca_ctrl[5]:I fz_dca_ctrl[4]:I fz_dca_ctrl[3]:I fz_dca_ctrl[2]:I
* .PININFO fz_dca_ctrl[1]:I fz_dca_ctrl[0]:I fz_irefgen[4]:I fz_irefgen[3]:I fz_irefgen[2]:I fz_irefgen[1]:I fz_irefgen[0]:I fz_ldo_bypass:I
* .PININFO fz_ldo_extrefsel:I fz_ldo_faststart:I fz_ldo_fbtrim[3]:I fz_ldo_fbtrim[2]:I fz_ldo_fbtrim[1]:I fz_ldo_fbtrim[0]:I fz_ldo_reftrim[3]:I
* .PININFO fz_ldo_reftrim[2]:I fz_ldo_reftrim[1]:I fz_ldo_reftrim[0]:I fz_ldo_vinvoltsel[1]:I fz_ldo_vinvoltsel[0]:I fz_lockcnt[2]:I fz_lockcnt[1]:I
* .PININFO fz_lockcnt[0]:I fz_lockforce:I fz_lockstickyb:I fz_lockthresh[3]:I fz_lockthresh[2]:I fz_lockthresh[1]:I fz_lockthresh[0]:I fz_lpfclksel:I
* .PININFO fz_nopfdpwrgate:I fz_pfd_pw[2]:I fz_pfd_pw[1]:I fz_pfd_pw[0]:I fz_pfddly[1]:I fz_pfddly[0]:I fz_skadj[4]:I fz_skadj[3]:I fz_skadj[2]:I
* .PININFO fz_skadj[1]:I fz_skadj[0]:I fz_spare[4]:I fz_spare[3]:I fz_spare[2]:I fz_spare[1]:I fz_spare[0]:I fz_startup[5]:I fz_startup[4]:I
* .PININFO fz_startup[3]:I fz_startup[2]:I fz_startup[1]:I fz_startup[0]:I fz_tight_loopb:I fz_vcosel:I fz_vcotrim[10]:I fz_vcotrim[9]:I
* .PININFO fz_vcotrim[8]:I fz_vcotrim[7]:I fz_vcotrim[6]:I fz_vcotrim[5]:I fz_vcotrim[4]:I fz_vcotrim[3]:I fz_vcotrim[2]:I fz_vcotrim[1]:I
* .PININFO fz_vcotrim[0]:I idfx_fscan_byprstb:I idfx_fscan_clkungate:I idfx_fscan_mode:I idfx_fscan_rstbypen:I idfx_fscan_sdi[2]:I idfx_fscan_sdi[1]:I
* .PININFO idfx_fscan_sdi[0]:I idfx_fscan_shiften:I idvdisable_bi:I idvfreqai:I idvfreqbi:I idvpulsei:I idvtclki:I idvtctrli:I idvtdi:I idvtresi:I
* .PININFO ldo_enable:I mash_order_plus_one:I mdiv_ratio[5]:I mdiv_ratio[4]:I mdiv_ratio[3]:I mdiv_ratio[2]:I mdiv_ratio[1]:I mdiv_ratio[0]:I p0:I
* .PININFO p1:I p2:I p3:I p4:I p5:I p6:I p8:I p9:I p12:I p13:I p14:I p39:I p40:I p44:I p45:I p50:I p51:I p61:I p62:I p63:I p64:I p_abuf0:I p_abuf1:I
* .PININFO p_abuf2:I p_abuf3:I p_abuf4:I p_abuf5:I p_abuf6:I p_abuf7:I p_abuf8:I p_abuf9:I p_abuf10:I p_abuf11:I p_abuf12:I p_abuf13:I p_abuf14:I
* .PININFO p_abuf15:I p_abuf16:I p_abuf17:I p_abuf18:I p_abuf19:I p_abuf20:I p_abuf21:I p_abuf22:I p_abuf23:I p_abuf24:I p_abuf25:I p_abuf26:I
* .PININFO p_abuf41:I p_abuf44:I p_abuf46:I p_abuf47:I p_aps0:I p_aps1:I pll_core__pfdlockrstnnnnh:I pll_fbgen__clkfbmxh:I plldistpwrgoodnnnnh:I
* .PININFO rationnnnh[9]:I rationnnnh[8]:I rationnnnh[7]:I rationnnnh[6]:I rationnnnh[5]:I rationnnnh[4]:I rationnnnh[3]:I rationnnnh[2]:I
* .PININFO rationnnnh[1]:I rationnnnh[0]:I reset_b_nnnnh:I ssc_cyc_to_peak_m1[8]:I ssc_cyc_to_peak_m1[7]:I ssc_cyc_to_peak_m1[6]:I
* .PININFO ssc_cyc_to_peak_m1[5]:I ssc_cyc_to_peak_m1[4]:I ssc_cyc_to_peak_m1[3]:I ssc_cyc_to_peak_m1[2]:I ssc_cyc_to_peak_m1[1]:I
* .PININFO ssc_cyc_to_peak_m1[0]:I ssc_en:I ssc_frac_step[23]:I ssc_frac_step[22]:I ssc_frac_step[21]:I ssc_frac_step[20]:I ssc_frac_step[19]:I
* .PININFO ssc_frac_step[18]:I ssc_frac_step[17]:I ssc_frac_step[16]:I ssc_frac_step[15]:I ssc_frac_step[14]:I ssc_frac_step[13]:I ssc_frac_step[12]:I
* .PININFO ssc_frac_step[11]:I ssc_frac_step[10]:I ssc_frac_step[9]:I ssc_frac_step[8]:I ssc_frac_step[7]:I ssc_frac_step[6]:I ssc_frac_step[5]:I
* .PININFO ssc_frac_step[4]:I ssc_frac_step[3]:I ssc_frac_step[2]:I ssc_frac_step[1]:I ssc_frac_step[0]:I tap_in[206]:I tap_in[205]:I tap_in[204]:I
* .PININFO tap_in[203]:I tap_in[202]:I tap_in[201]:I tap_in[200]:I tap_in[199]:I tap_in[198]:I tap_in[197]:I tap_in[196]:I tap_in[195]:I tap_in[194]:I
* .PININFO tap_in[193]:I tap_in[192]:I tap_in[191]:I tap_in[190]:I tap_in[189]:I tap_in[188]:I tap_in[187]:I tap_in[186]:I tap_in[185]:I tap_in[184]:I
* .PININFO tap_in[183]:I tap_in[182]:I tap_in[181]:I tap_in[180]:I tap_in[179]:I tap_in[178]:I tap_in[177]:I tap_in[176]:I tap_in[175]:I tap_in[174]:I
* .PININFO tap_in[173]:I tap_in[172]:I tap_in[171]:I tap_in[170]:I tap_in[169]:I tap_in[168]:I tap_in[167]:I tap_in[166]:I tap_in[165]:I tap_in[164]:I
* .PININFO tap_in[163]:I tap_in[162]:I tap_in[161]:I tap_in[160]:I tap_in[159]:I tap_in[158]:I tap_in[157]:I tap_in[156]:I tap_in[155]:I tap_in[154]:I
* .PININFO tap_in[153]:I tap_in[152]:I tap_in[151]:I tap_in[150]:I tap_in[149]:I tap_in[148]:I tap_in[147]:I tap_in[146]:I tap_in[145]:I tap_in[144]:I
* .PININFO tap_in[143]:I tap_in[142]:I tap_in[141]:I tap_in[140]:I tap_in[139]:I tap_in[138]:I tap_in[137]:I tap_in[136]:I tap_in[135]:I tap_in[134]:I
* .PININFO tap_in[133]:I tap_in[132]:I tap_in[131]:I tap_in[130]:I tap_in[129]:I tap_in[128]:I tap_in[127]:I tap_in[126]:I tap_in[125]:I tap_in[124]:I
* .PININFO tap_in[123]:I tap_in[122]:I tap_in[121]:I tap_in[120]:I tap_in[119]:I tap_in[118]:I tap_in[117]:I tap_in[116]:I tap_in[115]:I tap_in[114]:I
* .PININFO tap_in[113]:I tap_in[112]:I tap_in[111]:I tap_in[110]:I tap_in[109]:I tap_in[108]:I tap_in[107]:I tap_in[106]:I tap_in[105]:I tap_in[104]:I
* .PININFO tap_in[103]:I tap_in[102]:I tap_in[101]:I tap_in[100]:I tap_in[99]:I tap_in[98]:I tap_in[97]:I tap_in[96]:I tap_in[95]:I tap_in[94]:I
* .PININFO tap_in[93]:I tap_in[92]:I tap_in[91]:I tap_in[90]:I tap_in[89]:I tap_in[88]:I tap_in[87]:I tap_in[86]:I tap_in[85]:I tap_in[84]:I
* .PININFO tap_in[83]:I tap_in[82]:I tap_in[81]:I tap_in[80]:I tap_in[79]:I tap_in[78]:I tap_in[77]:I tap_in[76]:I tap_in[75]:I tap_in[74]:I
* .PININFO tap_in[73]:I tap_in[72]:I tap_in[71]:I tap_in[70]:I tap_in[69]:I tap_in[68]:I tap_in[67]:I tap_in[66]:I tap_in[65]:I tap_in[64]:I
* .PININFO tap_in[63]:I tap_in[62]:I tap_in[61]:I tap_in[60]:I tap_in[59]:I tap_in[58]:I tap_in[57]:I tap_in[56]:I tap_in[55]:I tap_in[54]:I
* .PININFO tap_in[53]:I tap_in[52]:I tap_in[51]:I tap_in[50]:I tap_in[49]:I tap_in[48]:I tap_in[47]:I tap_in[46]:I tap_in[45]:I tap_in[44]:I
* .PININFO tap_in[43]:I tap_in[42]:I tap_in[41]:I tap_in[40]:I tap_in[39]:I tap_in[38]:I tap_in[37]:I tap_in[36]:I tap_in[35]:I tap_in[34]:I
* .PININFO tap_in[33]:I tap_in[32]:I tap_in[31]:I tap_in[30]:I tap_in[29]:I tap_in[28]:I tap_in[27]:I tap_in[26]:I tap_in[25]:I tap_in[24]:I
* .PININFO tap_in[23]:I tap_in[22]:I tap_in[21]:I tap_in[20]:I tap_in[19]:I tap_in[18]:I tap_in[17]:I tap_in[16]:I tap_in[15]:I tap_in[14]:I
* .PININFO tap_in[13]:I tap_in[12]:I tap_in[11]:I tap_in[10]:I tap_in[9]:I tap_in[8]:I tap_in[7]:I tap_in[6]:I tap_in[5]:I tap_in[4]:I tap_in[3]:I
* .PININFO tap_in[2]:I tap_in[1]:I tap_in[0]:I test_sei:I test_si1:I vcodiv_ratio[1]:I vcodiv_ratio[0]:I vdd:I view_adc__dig_out[9]:I
* .PININFO view_adc__dig_out[8]:I view_adc__dig_out[7]:I view_adc__dig_out[6]:I view_adc__dig_out[5]:I view_adc__dig_out[4]:I view_adc__dig_out[3]:I
* .PININFO view_adc__dig_out[2]:I view_adc__dig_out[1]:I view_adc__dig_out[0]:I view_adc__done:I view_mux__viewoutnnnnh[1]:I
* .PININFO view_mux__viewoutnnnnh[0]:I vssx:I zdiv0_ratio[9]:I zdiv0_ratio[8]:I zdiv0_ratio[7]:I zdiv0_ratio[6]:I zdiv0_ratio[5]:I zdiv0_ratio[4]:I
* .PININFO zdiv0_ratio[3]:I zdiv0_ratio[2]:I zdiv0_ratio[1]:I zdiv0_ratio[0]:I zdiv0_ratio_p5:I zdiv1_ratio[9]:I zdiv1_ratio[8]:I zdiv1_ratio[7]:I
* .PININFO zdiv1_ratio[6]:I zdiv1_ratio[5]:I zdiv1_ratio[4]:I zdiv1_ratio[3]:I zdiv1_ratio[2]:I zdiv1_ratio[1]:I zdiv1_ratio[0]:I zdiv1_ratio_p5:I
* .PININFO adc_ctl__reset_bxxl:O adc_ctl__startxxh:O dfx__adc_chop_en:O dfx__adc_clkdiv[1]:O dfx__adc_clkdiv[0]:O dfx__adc_freeze:O
* .PININFO dfx__adc_sel_in[2]:O dfx__adc_sel_in[1]:O dfx__adc_sel_in[0]:O dfx__adc_use_vref:O dfx__cp1_trim[4]:O dfx__cp1_trim[3]:O dfx__cp1_trim[2]:O
* .PININFO dfx__cp1_trim[1]:O dfx__cp1_trim[0]:O dfx__cp2_trim[4]:O dfx__cp2_trim[3]:O dfx__cp2_trim[2]:O dfx__cp2_trim[1]:O dfx__cp2_trim[0]:O
* .PININFO dfx__cpnbias[1]:O dfx__cpnbias[0]:O dfx__dca_cb[1]:O dfx__dca_cb[0]:O dfx__dca_ctrl[5]:O dfx__dca_ctrl[4]:O dfx__dca_ctrl[3]:O
* .PININFO dfx__dca_ctrl[2]:O dfx__dca_ctrl[1]:O dfx__dca_ctrl[0]:O dfx__fz_irefgen_a[4]:O dfx__fz_irefgen_a[3]:O dfx__fz_irefgen_a[2]:O
* .PININFO dfx__fz_irefgen_a[1]:O dfx__fz_irefgen_a[0]:O dfx__fz_ldo_bypass_a:O dfx__fz_ldo_extrefsel_a:O dfx__fz_ldo_faststart_a:O
* .PININFO dfx__fz_ldo_fbtrim_a[3]:O dfx__fz_ldo_fbtrim_a[2]:O dfx__fz_ldo_fbtrim_a[1]:O dfx__fz_ldo_fbtrim_a[0]:O dfx__fz_ldo_reftrim_a[3]:O
* .PININFO dfx__fz_ldo_reftrim_a[2]:O dfx__fz_ldo_reftrim_a[1]:O dfx__fz_ldo_reftrim_a[0]:O dfx__fz_ldo_vinvoltsel_a[1]:O
* .PININFO dfx__fz_ldo_vinvoltsel_a[0]:O dfx__fz_lpfclksel_a:O dfx__fz_nopfdpwrgate_a:O dfx__fz_pfd_pw_a[2]:O dfx__fz_pfd_pw_a[1]:O
* .PININFO dfx__fz_pfd_pw_a[0]:O dfx__fz_pfddly_a[1]:O dfx__fz_pfddly_a[0]:O dfx__fz_spare_a[4]:O dfx__fz_spare_a[3]:O dfx__fz_spare_a[2]:O
* .PININFO dfx__fz_spare_a[1]:O dfx__fz_spare_a[0]:O dfx__fz_startup_a[5]:O dfx__fz_startup_a[4]:O dfx__fz_startup_a[3]:O dfx__fz_startup_a[2]:O
* .PININFO dfx__fz_startup_a[1]:O dfx__fz_startup_a[0]:O dfx__fz_vcosel_a:O dfx__fz_vcotrim_a[10]:O dfx__fz_vcotrim_a[9]:O dfx__fz_vcotrim_a[8]:O
* .PININFO dfx__fz_vcotrim_a[7]:O dfx__fz_vcotrim_a[6]:O dfx__fz_vcotrim_a[5]:O dfx__fz_vcotrim_a[4]:O dfx__fz_vcotrim_a[3]:O dfx__fz_vcotrim_a[2]:O
* .PININFO dfx__fz_vcotrim_a[1]:O dfx__fz_vcotrim_a[0]:O dfx__ldo_enable_a:O dfx__lockthresh[3]:O dfx__lockthresh[2]:O dfx__lockthresh[1]:O
* .PININFO dfx__lockthresh[0]:O dfx__mdiv_ratio_a[5]:O dfx__mdiv_ratio_a[4]:O dfx__mdiv_ratio_a[3]:O dfx__mdiv_ratio_a[2]:O dfx__mdiv_ratio_a[1]:O
* .PININFO dfx__mdiv_ratio_a[0]:O dfx__powergood:O dfx__reset_b:O dfx__skadj_ctrl[4]:O dfx__skadj_ctrl[3]:O dfx__skadj_ctrl[2]:O dfx__skadj_ctrl[1]:O
* .PININFO dfx__skadj_ctrl[0]:O dfx__ta_ldo_hiz_debug:O dfx__ta_ldo_idq_debug:O dfx__ta_spare[4]:O dfx__ta_spare[3]:O dfx__ta_spare[2]:O
* .PININFO dfx__ta_spare[1]:O dfx__ta_spare[0]:O dfx__tight_loop:O dfx__vcodiv_ratio_a[1]:O dfx__vcodiv_ratio_a[0]:O dfx__viewanaennnnnh[1]:O
* .PININFO dfx__viewanaennnnnh[0]:O dfx__viewdigennnnnh[1]:O dfx__viewdigennnnnh[0]:O dfx__viewselnnnnh[9]:O dfx__viewselnnnnh[8]:O
* .PININFO dfx__viewselnnnnh[7]:O dfx__viewselnnnnh[6]:O dfx__viewselnnnnh[5]:O dfx__viewselnnnnh[4]:O dfx__viewselnnnnh[3]:O dfx__viewselnnnnh[2]:O
* .PININFO dfx__viewselnnnnh[1]:O dfx__viewselnnnnh[0]:O dfx__zdiv0_ratio_a[9]:O dfx__zdiv0_ratio_a[8]:O dfx__zdiv0_ratio_a[7]:O
* .PININFO dfx__zdiv0_ratio_a[6]:O dfx__zdiv0_ratio_a[5]:O dfx__zdiv0_ratio_a[4]:O dfx__zdiv0_ratio_a[3]:O dfx__zdiv0_ratio_a[2]:O
* .PININFO dfx__zdiv0_ratio_a[1]:O dfx__zdiv0_ratio_a[0]:O dfx__zdiv0_ratio_p5_a:O dfx__zdiv1_ratio_a[9]:O dfx__zdiv1_ratio_a[8]:O
* .PININFO dfx__zdiv1_ratio_a[7]:O dfx__zdiv1_ratio_a[6]:O dfx__zdiv1_ratio_a[5]:O dfx__zdiv1_ratio_a[4]:O dfx__zdiv1_ratio_a[3]:O
* .PININFO dfx__zdiv1_ratio_a[2]:O dfx__zdiv1_ratio_a[1]:O dfx__zdiv1_ratio_a[0]:O dfx__zdiv1_ratio_p5_a:O earlylockxxnnnh:O
* .PININFO global_align__gateclkdistxxnnnl:O idv__cbctlth[2]:O idv__cbctlth[1]:O idv__cbctlth[0]:O idv__pgctlth[3]:O idv__pgctlth[2]:O
* .PININFO idv__pgctlth[1]:O idv__pgctlth[0]:O idv__rdacctlth[3]:O idv__rdacctlth[2]:O idv__rdacctlth[1]:O idv__rdacctlth[0]:O idv_fub__idvgateennh:O
* .PININFO idvdisable_bo:O idvfreqao:O idvfreqbo:O idvpulseo:O idvtctrlo:O idvtdo:O idvtreso:O lock_detector__rawlockxxnnnl:O lockxxnnnl:O
* .PININFO mash__halfintmxh:O mash__ratiomxh[9]:O mash__ratiomxh[8]:O mash__ratiomxh[7]:O mash__ratiomxh[6]:O mash__ratiomxh[5]:O mash__ratiomxh[4]:O
* .PININFO mash__ratiomxh[3]:O mash__ratiomxh[2]:O mash__ratiomxh[1]:O mash__ratiomxh[0]:O odfx_fscan_sdo[2]:O odfx_fscan_sdo[1]:O odfx_fscan_sdo[0]:O
* .PININFO reset_sync__bypassenxxnnnl:O reset_sync__bypassxxnnnl:O reset_sync__reset_b_xxnnnl:O ssc__directionmxh:O ssc_mod_dfx__clkmodmxh:O
* .PININFO startup_gen__pfdenxxh:O startup_gen__vctlrdacenxxh:O tap_out[61]:O tap_out[60]:O tap_out[59]:O tap_out[58]:O tap_out[57]:O tap_out[56]:O
* .PININFO tap_out[55]:O tap_out[54]:O tap_out[53]:O tap_out[52]:O tap_out[51]:O tap_out[50]:O tap_out[49]:O tap_out[48]:O tap_out[47]:O tap_out[46]:O
* .PININFO tap_out[45]:O tap_out[44]:O tap_out[43]:O tap_out[42]:O tap_out[41]:O tap_out[40]:O tap_out[39]:O tap_out[38]:O tap_out[37]:O tap_out[36]:O
* .PININFO tap_out[35]:O tap_out[34]:O tap_out[33]:O tap_out[32]:O tap_out[31]:O tap_out[30]:O tap_out[29]:O tap_out[28]:O tap_out[27]:O tap_out[26]:O
* .PININFO tap_out[25]:O tap_out[24]:O tap_out[23]:O tap_out[22]:O tap_out[21]:O tap_out[20]:O tap_out[19]:O tap_out[18]:O tap_out[17]:O tap_out[16]:O
* .PININFO tap_out[15]:O tap_out[14]:O tap_out[13]:O tap_out[12]:O tap_out[11]:O tap_out[10]:O tap_out[9]:O tap_out[8]:O tap_out[7]:O tap_out[6]:O
* .PININFO tap_out[5]:O tap_out[4]:O tap_out[3]:O tap_out[2]:O tap_out[1]:O tap_out[0]:O test_so1:O test_so2:O test_so3:O
* .PININFO tlctrl_sip__tightloopxxnnnh:O vctl_trim_fsm__vctlrdacshortxxh:O
Xu22 dfx__ta_openloop2 dfx__ta_vctlrdac[0] idv__rdacctlth_pre[0] n330 idv__rdacctlth[0] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu21 dfx__ta_openloop2 dfx__ta_vctlrdac[1] idv__rdacctlth_pre[1] n330 idv__rdacctlth[1] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu20 dfx__ta_openloop2 dfx__ta_vctlrdac[2] idv__rdacctlth_pre[2] n330 idv__rdacctlth[2] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu19 dfx__ta_openloop2 dfx__ta_vctlrdac[3] idv__rdacctlth_pre[3] n330 idv__rdacctlth[3] vdd vssx ringpll__b15ao0022al1n02x5 m=1
Xu48 viewout_cnt[0] viewout_cnt_next[0] vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu25 refclk_cnt[0] refclk_cnt_next[0] vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu3 idfx_fscan_rstbypen n44 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu46 lock_detector__earlylockxxnnnh n13 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu44 refclk_cnt_done_sticky n12 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu6 n330 startup_gen__vctlrdacenxxh vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu75 viewout_cnt[11] n28 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu70 viewout_cnt[9] n25 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu18 dfx__ta_openloop2 n330 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu36 refclk_cnt[4] n7 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu41 refclk_cnt[6] n10 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu53 viewout_cnt[3] n15 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu60 viewout_cnt[5] n19 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu65 viewout_cnt[7] n22 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu80 viewout_cnt[13] n31 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu37 n7 n8 n9 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu42 n10 n11 n34 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu54 n16 n15 n18 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu61 n19 n20 n21 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu66 n22 n23 n24 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu71 n25 n26 n27 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu76 n28 n29 n30 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu81 n31 n32 n35 vdd vssx ringpll__b15norp02al1n03x5 m=1
Xu38 n9 n8 n7 refclk_cnt_next[4] vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu43 n34 n11 n10 refclk_cnt_next[6] vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu55 n18 n16 n15 viewout_cnt_next[3] vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu62 n21 n20 n19 viewout_cnt_next[5] vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu67 n24 n23 n22 viewout_cnt_next[7] vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu72 n27 n26 n25 viewout_cnt_next[9] vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu77 n30 n29 n28 viewout_cnt_next[11] vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu82 n35 n32 n31 viewout_cnt_next[13] vdd vssx ringpll__b15aoi012al1n02x3 m=1
Xu52 n16 n14 viewout_cnt[2] viewout_cnt_next[2] vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu35 n8 n6 refclk_cnt[3] refclk_cnt_next[3] vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu40 n11 n9 refclk_cnt[5] refclk_cnt_next[5] vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu59 n20 n18 viewout_cnt[4] viewout_cnt_next[4] vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu64 n23 n21 viewout_cnt[6] viewout_cnt_next[6] vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu69 n26 n24 viewout_cnt[8] viewout_cnt_next[8] vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu74 n29 n27 viewout_cnt[10] viewout_cnt_next[10] vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu79 n32 n30 viewout_cnt[12] viewout_cnt_next[12] vdd vssx ringpll__b15oa0012al1n02x5 m=1
Xu8 idfx_fscan_rstbypen idfx_fscan_byprstb n1 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu34 n6 refclk_cnt[3] n8 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu39 n9 refclk_cnt[5] n11 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu58 n18 viewout_cnt[4] n20 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu63 n21 viewout_cnt[6] n23 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu68 n24 viewout_cnt[8] n26 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu73 n27 viewout_cnt[10] n29 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xu78 n30 viewout_cnt[12] n32 vdd vssx ringpll__b15nand02al1n03x5 m=1
Xrefclk_cnt_reg[1] refclkcount_clk refclk_cnt_next[1] refclk_cnt[1] n54 refclk_cnt[0] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xrefclk_cnt_reg[3] refclkcount_clk refclk_cnt_next[3] refclk_cnt[3] n54 refclk_cnt[2] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xrefclk_cnt_reg[5] refclkcount_clk refclk_cnt_next[5] refclk_cnt[5] n54 refclk_cnt[4] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xrefclk_cnt_reg[6] refclkcount_clk refclk_cnt_next[6] refclk_cnt[6] n54 refclk_cnt[5] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xrefclk_cnt_reg[4] refclkcount_clk refclk_cnt_next[4] refclk_cnt[4] n54 refclk_cnt[3] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xrefclk_cnt_reg[2] refclkcount_clk refclk_cnt_next[2] refclk_cnt[2] n54 refclk_cnt[1] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xrefclk_cnt_reg[0] refclkcount_clk refclk_cnt_next[0] refclk_cnt[0] n54 refclk_cnt_done_sticky p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xrefclk_cnt_done_sticky_reg refclkcount_clk n33 refclk_cnt_done_sticky n54 lock_timer__locktimecntxxnnnh[11] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xrefclk_cnt_reg[7] refclkcount_clk refclk_cnt_next[7] refclk_cnt[7] n54 refclk_cnt[6] p_abuf1 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xu88 viewout_cnt[14] n35 viewout_cnt_next[14] vdd vssx ringpll__b15xor002al1n02x5 m=1
Xu87 refclk_cnt[7] n34 refclk_cnt_next[7] vdd vssx ringpll__b15xor002al1n02x5 m=1
Xu50 n14 viewout_cnt[0] viewout_cnt[1] viewout_cnt_next[1] vdd vssx ringpll__b15oab012al1n02x5 m=1
Xu31 n6 n5 refclk_cnt[2] refclk_cnt_next[2] vdd vssx ringpll__b15oab012al1n02x5 m=1
Xu29 n5 refclk_cnt[0] refclk_cnt[1] refclk_cnt_next[1] vdd vssx ringpll__b15oab012al1n02x5 m=1
Xu15 lockxxnnnl dfx__start_measurement start_measurement_pre vdd vssx ringpll__b15and002al1n03x5 m=1
Xu83 startup_gen__pfdenxxh_pre n330 startup_gen__pfdenxxh vdd vssx ringpll__b15and002al1n03x5 m=1
Xu17 tlctrl_sip__tightloopxxnnnh_pre dfx__tllm_en tlctrl_sip__tightloopxxnnnh vdd vssx ringpll__b15and002al1n03x5 m=1
Xu84 tlctrl_sip__statexxnnnh_pre[0] dfx__tllm_en tlctrl_sip__statexxnnnh[0] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu85 tlctrl_sip__statexxnnnh_pre[1] dfx__tllm_en tlctrl_sip__statexxnnnh[1] vdd vssx ringpll__b15and002al1n03x5 m=1
Xu28 refclk_cnt[1] refclk_cnt[0] n5 vdd vssx ringpll__b15and002al1n03x5 m=1
Xu30 refclk_cnt[0] refclk_cnt[1] refclk_cnt[2] n6 vdd vssx ringpll__b15and003al1n02x5 m=1
Xu27 start_measurement refclk_cnt_done_sticky refclkcountergate vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu49 viewout_cnt[1] viewout_cnt_next[0] n14 vdd vssx ringpll__b15nonb02al1n02x3 m=1
Xu51 viewout_cnt[0] viewout_cnt[1] viewout_cnt[2] n16 vdd vssx ringpll__b15nand03al1n03x5 m=1
Xunlock_counter clkrefxxh reset_sync__reset_b_xxnnnl lockxxnnnl lock_detector__rawlockxxnnnl idfx_fscan_clkungate test_so3 unlock_counter__unlockcountxxnnnh_0 refclk_cnt[7] n60 n64 test_so2 p_abuf6 vdd vssx p_abuf7 p_abuf9 p_abuf44 p9 ringpll__unlock_counter
Xvctl_trim_fsm clkrefxxh reset_sync__reset_b_xxnnnl dmfix_synopsys_unconnected_44 dmfix_synopsys_unconnected_45 dmfix_synopsys_unconnected_46 dmfix_synopsys_unconnected_47 dmfix_synopsys_unconnected_48 vctl_trim_fsm__vctlrdacshortxxh_pre dmfix_synopsys_unconnected_49 dmfix_synopsys_unconnected_50 dmfix_synopsys_unconnected_51 dmfix_synopsys_unconnected_52 idfx_fscan_rstbypen idfx_fscan_byprstb unlock_counter__unlockcountxxnnnh_0 test_so1 p_abuf5 vdd vssx p_abuf8 p_abuf9 p_abuf9 p63 p14 ringpll__vctl_trim_fsm
Xu45 n12 refclk_cnt[7] n34 n33 vdd vssx ringpll__b15oaib12el1n02x5 m=1
Xstartup_gen clkrefxxh reset_sync__reset_b_xxnnnl dmfix_synopsys_unconnected_41 dmfix_synopsys_unconnected_42 dmfix_synopsys_unconnected_43 startup_gen__pfdenxxh_pre lock_timer__locktimecntxxnnnh[1] p_abuf5 vdd vssx p_abuf5 p64 ringpll__startup_gen
Xu47 dfx__tllm_en tlctrl_sip__earlylockxxnnnh dfx__tllm_en n13 earlylockxxnnnh vdd vssx ringpll__b15naoai3en1n04x5 m=1
Xadc_ctl clkrefxxh dfx__adc_start dfx__adc_start_cnt[1] dfx__adc_start_cnt[0] adc_ctl__startxxh adc_ctl__reset_bxxl idfx_fscan_rstbypen idfx_fscan_clkungate idfx_fscan_byprstb idfx_fscan_sdi[2] n57 p_abuf0 vdd vssx p_abuf2 p3 p12 cts0 p_abuf42 ringpll__adc_ctl
Xclkgateenviewclkcount_clk viewclkcount_clk measurement_viewclk idfx_fscan_clkungate p_abuf47 vdd vssx ringpll__clkgateen_0
Xu14 n3 start_measurement refclk_cnt_rst_pre vdd vssx ringpll__b15nanb02an1n02x5 m=1
Xu24 vctl_trim_fsm__vctlrdacshortxxh_pre n330 vctl_trim_fsm__vctlrdacshortxxh vdd vssx ringpll__b15nanb02an1n02x5 m=1
Xclkgateenrefclkcount_clk refclkcount_clk refclkcountergate idfx_fscan_clkungate p_abuf44 vdd vssx ringpll__clkgateen_1
Xu57 dfx__reset_b n44 idfx_fscan_rstbypen n360 localreset vdd vssx ringpll__b15aboi22an1n04x3 m=1
Xu13 dfx__reset_b n3 vdd vssx ringpll__b15inv040al1n03x5 m=1
Xu56 idfx_fscan_byprstb n360 vdd vssx ringpll__b15inv040al1n03x5 m=1
Xu94 refclk_cnt_7x0__rst n54 vdd vssx ringpll__b15inv040an1n06x5 m=1
Xviewout_cnt_reg[4] viewclkcount_clk viewout_cnt_next[4] viewout_cnt[4] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[9] viewclkcount_clk viewout_cnt_next[9] viewout_cnt[9] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[11] viewclkcount_clk viewout_cnt_next[11] viewout_cnt[11] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[6] viewclkcount_clk viewout_cnt_next[6] viewout_cnt[6] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[12] viewclkcount_clk viewout_cnt_next[12] viewout_cnt[12] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[13] viewclkcount_clk viewout_cnt_next[13] viewout_cnt[13] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[10] viewclkcount_clk viewout_cnt_next[10] viewout_cnt[10] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[8] viewclkcount_clk viewout_cnt_next[8] viewout_cnt[8] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[3] viewclkcount_clk viewout_cnt_next[3] viewout_cnt[3] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[14] viewclkcount_clk viewout_cnt_next[14] viewout_cnt[14] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[2] viewclkcount_clk viewout_cnt_next[2] viewout_cnt[2] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[5] viewclkcount_clk viewout_cnt_next[5] viewout_cnt[5] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[7] viewclkcount_clk viewout_cnt_next[7] viewout_cnt[7] n54 vdd vssx ringpll__b15fqn003al1n02x3 m=1
Xviewout_cnt_reg[0] viewclkcount_clk viewout_cnt_next[0] viewout_cnt[0] n54 vdd vssx ringpll__b15fqn003al1n02x5 m=1
Xviewout_cnt_reg[1] viewclkcount_clk viewout_cnt_next[1] viewout_cnt[1] n54 vdd vssx ringpll__b15fqn003al1n02x5 m=1
Xu10 dmfix_synopsys_unconnected_72 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xlock_detector dfx__fz_lockforce_a dfx__fz_lockcnt_a[2] dfx__fz_lockcnt_a[1] dfx__fz_lockcnt_a[0] clkrefxxh dfx__openloop dmfix_synopsys_unconnected_1 pll_core__pfdlockrstnnnnh reset_sync__reset_b_xxnnnl reset_sync__bypassxxnnnl reset_sync__bypassenxxnnnl dfx__reset_b tlctrl_sip__lockrstxxnnnh lock_detector__rawlockxxnnnl lock_detector__earlylockxxnnnh aps_rename_1432 idfx_fscan_rstbypen idfx_fscan_clkungate idfx_fscan_byprstb idfx_fscan_sdi[1] test_si1 n61 n66 test_sei vdd vssx p_abuf4 p_abuf7 p5 p44 p_abuf27 p_abuf28 p_abuf29 p_abuf30 lockxxnnnl p_abuf32 p_abuf33 p_abuf34 p_abuf35 cts0 p_abuf42 ringpll__lock_detector
Xu32 n360 refclk_cnt_rst_pre refclk_cnt_7x0__rst idfx_fscan_rstbypen vdd vssx ringpll__b15cmbn22ah1n32x5 m=1
Xu1080 net546 net514 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu849 net1 net80 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu848 net80 net79 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu842 net79 net73 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1 measurement_refclk net1 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu847 net73 net78 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1120 net75 net554 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu844 net450 net75 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1016 tlctrl_sip__lockrstxxnnnh_pre net450 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xu1112 net554 net546 vdd vssx ringpll__b15bfn001al1n06x5 m=1
Xlock_timer clkrefxxh reset_sync__reset_b_xxnnnl lockxxnnnl lock_timer__locktimecntxxnnnh[11] lock_timer__locktimecntxxnnnh[10] lock_timer__locktimecntxxnnnh[9] lock_timer__locktimecntxxnnnh[8] lock_timer__locktimecntxxnnnh[7] lock_timer__locktimecntxxnnnh[6] lock_timer__locktimecntxxnnnh[5] lock_timer__locktimecntxxnnnh[4] lock_timer__locktimecntxxnnnh[3] lock_timer__locktimecntxxnnnh[2] lock_timer__locktimecntxxnnnh[1] lock_timer__locktimecntxxnnnh[0] idfx_fscan_clkungate n57 n66 p_abuf0 vdd vssx p_abuf2 p_abuf3 p_abuf44 ringpll__lock_timer
Xctech_lib_doublesync_rstbmeasurement_viewclk_rccu1 view_mux__viewoutnnnnh[0] net78 measurement_viewclk localreset p8 p50 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xctech_lib_doublesync_rstbstart_measurement_rccu1 clkrefxxh start_measurement_pre start_measurement localreset p8 p50 vdd vssx ringpll__b15fmy203al1n04x5 m=1
Xu86 refclk_cnt_7x0__rst refclk_cnt_done_sticky measurement_refclk vdd vssx ringpll__b15nor002an1n03x5 m=1
Xreset_sync cts0 dfx__reset_b dfx__bypass dfx__ldo_enable_a dfx__fz_spare_a[1] dfx__fz_spare_a[0] reset_sync__bypassxxnnnl reset_sync__reset_b_xxnnnl_pre reset_sync__bypassenxxnnnl idfx_fscan_rstbypen idfx_fscan_byprstb n61 p_abuf8 vdd vssx p_abuf5 p_abuf5 p40 p51 p13 ringpll__ljpll_reset_sync
Xsync_reset_clkgen clkrefxxh pll_fbgen__clkfbmxh reset_sync__bypassenxxnnnl earlylockxxnnnh lockxxnnnl dm_sync_reset_clkgen__clkfbgatemxh idfx_fscan_rstbypen dmfix_synopsys_unconnected_56 idfx_fscan_byprstb reset_sync__bypassxxnnnl startup_gen__pfdenxxh_pre n60 n65 p_abuf5 vdd vssx p6 p45 cts0 p_abuf42 p_abuf46 ringpll__sync_reset_clkgen
Xreg_req_ack p_abuf40 p_abuf33 dmfix_synopsys_unconnected_53 dmfix_synopsys_unconnected_54 dmfix_synopsys_unconnected_55 ssc__profupdatemxh ssc__ratioupdatemxh reg_req_ack__sscprofupdreqmxh reg_req_ack__sscprofupdackmxh reg_req_ack__ratioupdreqmxh reg_req_ack__ratioupdackmxh reg_req_ack__mashstateresetmxh vdd vssx p0 p_abuf36 p_abuf37 p_abuf38 p_abuf39 p61 ringpll__reg_req_ack
Xu33 net514 p2 tlctrl_sip__lockrstxxnnnh dfx__tllm_en vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xssc_modxssc p_abuf31 aps_rename_1432 dmfix_synopsys_unconnected_57 dmfix_synopsys_unconnected_58 dmfix_synopsys_unconnected_59 dmfix_synopsys_unconnected_60 dmfix_synopsys_unconnected_61 dmfix_synopsys_unconnected_62 dmfix_synopsys_unconnected_63 dmfix_synopsys_unconnected_64 dmfix_synopsys_unconnected_65 dmfix_synopsys_unconnected_66 dfx__fracstepnh[23] dfx__fracstepnh[22] dfx__fracstepnh[21] dfx__fracstepnh[20] dfx__fracstepnh[19] dfx__fracstepnh[18] dfx__fracstepnh[17] dfx__fracstepnh[16] dfx__fracstepnh[15] dfx__fracstepnh[14] dfx__fracstepnh[13] dfx__fracstepnh[12] dfx__fracstepnh[11] dfx__fracstepnh[10] dfx__fracstepnh[9] dfx__fracstepnh[8] dfx__fracstepnh[7] dfx__fracstepnh[6] dfx__fracstepnh[5] dfx__fracstepnh[4] dfx__fracstepnh[3] dfx__fracstepnh[2] dfx__fracstepnh[1] dfx__fracstepnh[0] dfx__ssc_en dmfix_synopsys_unconnected_67 dmfix_synopsys_unconnected_68 dfx__ssc_cyc_to_peak_m1[8] dfx__ssc_cyc_to_peak_m1[7] dfx__ssc_cyc_to_peak_m1[6] dfx__ssc_cyc_to_peak_m1[5] dfx__ssc_cyc_to_peak_m1[4] dfx__ssc_cyc_to_peak_m1[3] dfx__ssc_cyc_to_peak_m1[2] dfx__ssc_cyc_to_peak_m1[1] dfx__ssc_cyc_to_peak_m1[0] reg_req_ack__sscprofupdreqmxh reg_req_ack__sscprofupdackmxh reg_req_ack__ratioupdreqmxh reg_req_ack__ratioupdackmxh dfx__ratio[9] dfx__ratio[8] dfx__ratio[7] dfx__ratio[6] dfx__ratio[5] dfx__ratio[4] dfx__ratio[3] dfx__ratio[2] dfx__ratio[1] dfx__ratio[0] dfx__fraction[23] dfx__fraction[22] dfx__fraction[21] dfx__fraction[20] dfx__fraction[19] dfx__fraction[18] dfx__fraction[17] dfx__fraction[16] dfx__fraction[15] dfx__fraction[14] dfx__fraction[13] dfx__fraction[12] dfx__fraction[11] dfx__fraction[10] dfx__fraction[9] dfx__fraction[8] dfx__fraction[7] dfx__fraction[6] dfx__fraction[5] dfx__fraction[4] dfx__fraction[3] dfx__fraction[2] dfx__fraction[1] dfx__fraction[0] ssc__ratiomxh[9] ssc__ratiomxh[8] ssc__ratiomxh[7] ssc__ratiomxh[6] ssc__ratiomxh[5] ssc__ratiomxh[4] ssc__ratiomxh[3] ssc__ratiomxh[2] ssc__ratiomxh[1] ssc__ratiomxh[0] ssc__fractionmxh[23] ssc__fractionmxh[22] ssc__fractionmxh[21] ssc__fractionmxh[20] ssc__fractionmxh[19] ssc__fractionmxh[18] ssc__fractionmxh[17] ssc__fractionmxh[16] ssc__fractionmxh[15] ssc__fractionmxh[14] ssc__fractionmxh[13] ssc__fractionmxh[12] ssc__fractionmxh[11] ssc__fractionmxh[10] ssc__fractionmxh[9] ssc__fractionmxh[8] ssc__fractionmxh[7] ssc__fractionmxh[6] ssc__fractionmxh[5] ssc__fractionmxh[4] ssc__fractionmxh[3] ssc__fractionmxh[2] ssc__fractionmxh[1] ssc__fractionmxh[0] ssc__directionmxh ssc__profupdatemxh ssc__ratioupdatemxh vdd vssx aps_rename_1432 p1 p_abuf39 ringpll__ssc_mod
Xmash_modxmash p_abuf40 p_abuf30 p_abuf37 dfx__mash_order_plus_one ratio_async_mux__ratiomxh[9] ratio_async_mux__ratiomxh[8] ratio_async_mux__ratiomxh[7] ratio_async_mux__ratiomxh[6] ratio_async_mux__ratiomxh[5] ratio_async_mux__ratiomxh[4] ratio_async_mux__ratiomxh[3] ratio_async_mux__ratiomxh[2] ratio_async_mux__ratiomxh[1] ratio_async_mux__ratiomxh[0] ratio_async_mux__fractionmxh[23] ratio_async_mux__fractionmxh[22] ratio_async_mux__fractionmxh[21] ratio_async_mux__fractionmxh[20] ratio_async_mux__fractionmxh[19] ratio_async_mux__fractionmxh[18] ratio_async_mux__fractionmxh[17] ratio_async_mux__fractionmxh[16] ratio_async_mux__fractionmxh[15] ratio_async_mux__fractionmxh[14] ratio_async_mux__fractionmxh[13] ratio_async_mux__fractionmxh[12] ratio_async_mux__fractionmxh[11] ratio_async_mux__fractionmxh[10] ratio_async_mux__fractionmxh[9] ratio_async_mux__fractionmxh[8] ratio_async_mux__fractionmxh[7] ratio_async_mux__fractionmxh[6] ratio_async_mux__fractionmxh[5] ratio_async_mux__fractionmxh[4] ratio_async_mux__fractionmxh[3] ratio_async_mux__fractionmxh[2] ratio_async_mux__fractionmxh[1] ratio_async_mux__fractionmxh[0] tap_out[43] mash__ratiomxh[8] mash__ratiomxh[7] mash__ratiomxh[6] mash__ratiomxh[5] mash__ratiomxh[4] mash__ratiomxh[3] mash__ratiomxh[2] mash__ratiomxh[1] mash__ratiomxh[0] mash__halfintmxh dmfix_synopsys_unconnected_70 vdd vssx p_abuf34 p_abuf29 p_abuf27 p_abuf28 p_abuf39 p_abuf27 p_abuf33 p_abuf28 p_abuf36 p_abuf36 p_abuf36 reg_req_ack__mashstateresetmxh p_abuf32 p_abuf35 p_abuf38 ssc_mod_dfx__clkmodmxh p62 ringpll__mash_mod
Xu9 n1 reset_sync__reset_b_xxnnnl_pre n44 reset_sync__reset_b_xxnnnl vdd vssx ringpll__b15aob012an1n24x5 m=1
Xratio_async_mux reset_sync__bypassxxnnnl lockxxnnnl dfx__ratio[9] dfx__ratio[8] dfx__ratio[7] dfx__ratio[6] dfx__ratio[5] dfx__ratio[4] dfx__ratio[3] dfx__ratio[2] dfx__ratio[1] dfx__ratio[0] ssc__ratiomxh[9] ssc__ratiomxh[8] ssc__ratiomxh[7] ssc__ratiomxh[6] ssc__ratiomxh[5] ssc__ratiomxh[4] ssc__ratiomxh[3] ssc__ratiomxh[2] ssc__ratiomxh[1] ssc__ratiomxh[0] dfx__fraction[23] dfx__fraction[22] dfx__fraction[21] dfx__fraction[20] dfx__fraction[19] dfx__fraction[18] dfx__fraction[17] dfx__fraction[16] dfx__fraction[15] dfx__fraction[14] dfx__fraction[13] dfx__fraction[12] dfx__fraction[11] dfx__fraction[10] dfx__fraction[9] dfx__fraction[8] dfx__fraction[7] dfx__fraction[6] dfx__fraction[5] dfx__fraction[4] dfx__fraction[3] dfx__fraction[2] dfx__fraction[1] dfx__fraction[0] ssc__fractionmxh[23] ssc__fractionmxh[22] ssc__fractionmxh[21] ssc__fractionmxh[20] ssc__fractionmxh[19] ssc__fractionmxh[18] ssc__fractionmxh[17] ssc__fractionmxh[16] ssc__fractionmxh[15] ssc__fractionmxh[14] ssc__fractionmxh[13] ssc__fractionmxh[12] ssc__fractionmxh[11] ssc__fractionmxh[10] ssc__fractionmxh[9] ssc__fractionmxh[8] ssc__fractionmxh[7] ssc__fractionmxh[6] ssc__fractionmxh[5] ssc__fractionmxh[4] ssc__fractionmxh[3] ssc__fractionmxh[2] ssc__fractionmxh[1] ssc__fractionmxh[0] dfx__mdiv_ratio_a[5] dfx__mdiv_ratio_a[4] dfx__mdiv_ratio_a[3] dfx__mdiv_ratio_a[2] dfx__mdiv_ratio_a[1] dmfix_synopsys_unconnected_69 ratio_async_mux__ratiomxh[9] ratio_async_mux__ratiomxh[8] ratio_async_mux__ratiomxh[7] ratio_async_mux__ratiomxh[6] ratio_async_mux__ratiomxh[5] ratio_async_mux__ratiomxh[4] ratio_async_mux__ratiomxh[3] ratio_async_mux__ratiomxh[2] ratio_async_mux__ratiomxh[1] ratio_async_mux__ratiomxh[0] ratio_async_mux__fractionmxh[23] ratio_async_mux__fractionmxh[22] ratio_async_mux__fractionmxh[21] ratio_async_mux__fractionmxh[20] ratio_async_mux__fractionmxh[19] ratio_async_mux__fractionmxh[18] ratio_async_mux__fractionmxh[17] ratio_async_mux__fractionmxh[16] ratio_async_mux__fractionmxh[15] ratio_async_mux__fractionmxh[14] ratio_async_mux__fractionmxh[13] ratio_async_mux__fractionmxh[12] ratio_async_mux__fractionmxh[11] ratio_async_mux__fractionmxh[10] ratio_async_mux__fractionmxh[9] ratio_async_mux__fractionmxh[8] ratio_async_mux__fractionmxh[7] ratio_async_mux__fractionmxh[6] ratio_async_mux__fractionmxh[5] ratio_async_mux__fractionmxh[4] ratio_async_mux__fractionmxh[3] ratio_async_mux__fractionmxh[2] ratio_async_mux__fractionmxh[1] ratio_async_mux__fractionmxh[0] vdd vssx ringpll__ratio_async_mux
Xmash_modxssc_mod_dfx dm_sync_reset_clkgen__clkfbgatemxh p_abuf33 dfx__sscmodtrignh dfx__sscmodstepsnh[1] dfx__sscmodstepsnh[0] dfx__sscdfxennh dfx__sscmodclkdivnh[1] dfx__sscmodclkdivnh[0] ssc_mod_dfx__triggerregxdh ssc_mod_dfx__modulatorennh p_abuf40 vdd vssx p4 p39 p_abuf31 p_abuf39 ssc_mod_dfx__clkmodmxh ringpll__ssc_mod_dfx
Xdfx adc_ctl__startxxh bypassnnnnh dfx__adc_chop_en dfx__adc_clkdiv[1] dfx__adc_clkdiv[0] dfx__adc_freeze dfx__adc_sel_in[2] dfx__adc_sel_in[1] dfx__adc_sel_in[0] dfx__adc_start dfx__adc_start_cnt[1] dfx__adc_start_cnt[0] dfx__adc_use_vref dfx__bypass dfx__cp1_trim[4] dfx__cp1_trim[3] dfx__cp1_trim[2] dfx__cp1_trim[1] dfx__cp1_trim[0] dfx__cp2_trim[4] dfx__cp2_trim[3] dfx__cp2_trim[2] dfx__cp2_trim[1] dfx__cp2_trim[0] dfx__cpnbias[1] dfx__cpnbias[0] dfx__dca_cb[1] dfx__dca_cb[0] dfx__dca_ctrl[5] dfx__dca_ctrl[4] dfx__dca_ctrl[3] dfx__dca_ctrl[2] dfx__dca_ctrl[1] dfx__dca_ctrl[0] dmfix_synopsys_unconnected_21 dfx__fracstepnh[23] dfx__fracstepnh[22] dfx__fracstepnh[21] dfx__fracstepnh[20] dfx__fracstepnh[19] dfx__fracstepnh[18] dfx__fracstepnh[17] dfx__fracstepnh[16] dfx__fracstepnh[15] dfx__fracstepnh[14] dfx__fracstepnh[13] dfx__fracstepnh[12] dfx__fracstepnh[11] dfx__fracstepnh[10] dfx__fracstepnh[9] dfx__fracstepnh[8] dfx__fracstepnh[7] dfx__fracstepnh[6] dfx__fracstepnh[5] dfx__fracstepnh[4] dfx__fracstepnh[3] dfx__fracstepnh[2] dfx__fracstepnh[1] dfx__fracstepnh[0] dfx__fraction[23] dfx__fraction[22] dfx__fraction[21] dfx__fraction[20] dfx__fraction[19] dfx__fraction[18] dfx__fraction[17] dfx__fraction[16] dfx__fraction[15] dfx__fraction[14] dfx__fraction[13] dfx__fraction[12] dfx__fraction[11] dfx__fraction[10] dfx__fraction[9] dfx__fraction[8] dfx__fraction[7] dfx__fraction[6] dfx__fraction[5] dfx__fraction[4] dfx__fraction[3] dfx__fraction[2] dfx__fraction[1] dfx__fraction[0] dfx__fz_irefgen_a[4] dfx__fz_irefgen_a[3] dfx__fz_irefgen_a[2] dfx__fz_irefgen_a[1] dfx__fz_irefgen_a[0] dfx__fz_ldo_bypass_a dfx__fz_ldo_extrefsel_a dfx__fz_ldo_faststart_a dfx__fz_ldo_fbtrim_a[3] dfx__fz_ldo_fbtrim_a[2] dfx__fz_ldo_fbtrim_a[1] dfx__fz_ldo_fbtrim_a[0] dfx__fz_ldo_reftrim_a[3] dfx__fz_ldo_reftrim_a[2] dfx__fz_ldo_reftrim_a[1] dfx__fz_ldo_reftrim_a[0] dfx__fz_ldo_vinvoltsel_a[1] dfx__fz_ldo_vinvoltsel_a[0] dfx__fz_lockcnt_a[2] dfx__fz_lockcnt_a[1] dfx__fz_lockcnt_a[0] dfx__fz_lockforce_a dfx__fz_lpfclksel_a dfx__fz_nopfdpwrgate_a dfx__fz_pfd_pw_a[2] dfx__fz_pfd_pw_a[1] dfx__fz_pfd_pw_a[0] dfx__fz_pfddly_a[1] dfx__fz_pfddly_a[0] dfx__fz_spare_a[4] dfx__fz_spare_a[3] dfx__fz_spare_a[2] dfx__fz_spare_a[1] dfx__fz_spare_a[0] dfx__fz_startup_a[5] dfx__fz_startup_a[4] dfx__fz_startup_a[3] dfx__fz_startup_a[2] dfx__fz_startup_a[1] dfx__fz_startup_a[0] dfx__fz_vcosel_a dfx__fz_vcotrim_a[10] n17 n36 n37 n38 dfx__fz_vcotrim_a[5] dfx__fz_vcotrim_a[4] dfx__fz_vcotrim_a[3] n39 n40 n41 dmfix_synopsys_unconnected_20 dfx__ldo_enable_a dmfix_synopsys_unconnected_25 dfx__lockthresh[3] dfx__lockthresh[2] dfx__lockthresh[1] dfx__lockthresh[0] dfx__mash_order_plus_one dfx__mdiv_ratio_a[5] dfx__mdiv_ratio_a[4] dfx__mdiv_ratio_a[3] dfx__mdiv_ratio_a[2] dfx__mdiv_ratio_a[1] dfx__mdiv_ratio_a[0] dfx__openloop dmfix_synopsys_unconnected_22 dmfix_synopsys_unconnected_23 dmfix_synopsys_unconnected_24 dfx__powergood dfx__ratio[9] dfx__ratio[8] dfx__ratio[7] dfx__ratio[6] dfx__ratio[5] dfx__ratio[4] dfx__ratio[3] dfx__ratio[2] dfx__ratio[1] dfx__ratio[0] dmfix_synopsys_unconnected_26 dfx__reset_b dfx__skadj_ctrl[4] dfx__skadj_ctrl[3] dfx__skadj_ctrl[2] dfx__skadj_ctrl[1] dfx__skadj_ctrl[0] dfx__ssc_cyc_to_peak_m1[8] dfx__ssc_cyc_to_peak_m1[7] dfx__ssc_cyc_to_peak_m1[6] dfx__ssc_cyc_to_peak_m1[5] dfx__ssc_cyc_to_peak_m1[4] dfx__ssc_cyc_to_peak_m1[3] dfx__ssc_cyc_to_peak_m1[2] dfx__ssc_cyc_to_peak_m1[1] dfx__ssc_cyc_to_peak_m1[0] dfx__ssc_en dmfix_synopsys_unconnected_28 dfx__sscdfxennh dfx__sscmodclkdivnh[1] dfx__sscmodclkdivnh[0] dfx__sscmodstepsnh[1] dfx__sscmodstepsnh[0] dfx__sscmodtrignh dfx__start_measurement dfx__ta_ldo_hiz_debug dfx__ta_ldo_idq_debug dfx__ta_openloop2 dfx__ta_spare[4] dfx__ta_spare[3] dfx__ta_spare[2] dfx__ta_spare[1] dfx__ta_spare[0] dfx__ta_vctlrdac[3] dfx__ta_vctlrdac[2] dfx__ta_vctlrdac[1] dfx__ta_vctlrdac[0] dfx__tight_loop dfx__tllm_en dfx__vcodiv_ratio_a[1] dfx__vcodiv_ratio_a[0] dfx__viewanaennnnnh[1] dfx__viewanaennnnnh[0] dfx__viewdigennnnnh[1] dfx__viewdigennnnnh[0] dfx__viewselnnnnh[9] dfx__viewselnnnnh[8] dfx__viewselnnnnh[7] dfx__viewselnnnnh[6] dfx__viewselnnnnh[5] dfx__viewselnnnnh[4] dfx__viewselnnnnh[3] dfx__viewselnnnnh[2] dfx__viewselnnnnh[1] dfx__viewselnnnnh[0] dfx__zdiv0_ratio_a[9] dfx__zdiv0_ratio_a[8] dfx__zdiv0_ratio_a[7] dfx__zdiv0_ratio_a[6] dfx__zdiv0_ratio_a[5] dfx__zdiv0_ratio_a[4] dfx__zdiv0_ratio_a[3] dfx__zdiv0_ratio_a[2] dfx__zdiv0_ratio_a[1] dfx__zdiv0_ratio_a[0] dfx__zdiv0_ratio_p5_a dfx__zdiv1_ratio_a[9] dfx__zdiv1_ratio_a[8] dfx__zdiv1_ratio_a[7] dfx__zdiv1_ratio_a[6] dfx__zdiv1_ratio_a[5] dfx__zdiv1_ratio_a[4] dfx__zdiv1_ratio_a[3] dfx__zdiv1_ratio_a[2] dfx__zdiv1_ratio_a[1] dfx__zdiv1_ratio_a[0] dfx__zdiv1_ratio_p5_a dmfix_synopsys_unconnected_2 dmfix_synopsys_unconnected_3 dmfix_synopsys_unconnected_4 dmfix_synopsys_unconnected_5 dmfix_synopsys_unconnected_6 dmfix_synopsys_unconnected_7 dmfix_synopsys_unconnected_8 dmfix_synopsys_unconnected_9 dmfix_synopsys_unconnected_10 dmfix_synopsys_unconnected_11 dmfix_synopsys_unconnected_12 dmfix_synopsys_unconnected_13 fractionnnnnh[23] fractionnnnnh[22] fractionnnnnh[21] fractionnnnnh[20] fractionnnnnh[19] fractionnnnnh[18] fractionnnnnh[17] fractionnnnnh[16] fractionnnnnh[15] fractionnnnnh[14] fractionnnnnh[13] fractionnnnnh[12] fractionnnnnh[11] fractionnnnnh[10] fractionnnnnh[9] fractionnnnnh[8] fractionnnnnh[7] fractionnnnnh[6] fractionnnnnh[5] fractionnnnnh[4] fractionnnnnh[3] fractionnnnnh[2] fractionnnnnh[1] fractionnnnnh[0] fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] fz_cpnbias[1] fz_cpnbias[0] fz_dca_cb[1] fz_dca_cb[0] fz_dca_ctrl[5] fz_dca_ctrl[4] fz_dca_ctrl[3] fz_dca_ctrl[2] fz_dca_ctrl[1] fz_dca_ctrl[0] fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] fz_ldo_bypass fz_ldo_extrefsel fz_ldo_faststart fz_ldo_fbtrim[3] fz_ldo_fbtrim[2] fz_ldo_fbtrim[1] fz_ldo_fbtrim[0] fz_ldo_reftrim[3] fz_ldo_reftrim[2] fz_ldo_reftrim[1] fz_ldo_reftrim[0] fz_ldo_vinvoltsel[1] fz_ldo_vinvoltsel[0] fz_lockcnt[2] fz_lockcnt[1] fz_lockcnt[0] fz_lockforce dmfix_synopsys_unconnected_32 fz_lockthresh[3] fz_lockthresh[2] fz_lockthresh[1] fz_lockthresh[0] fz_lpfclksel fz_nopfdpwrgate fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] fz_pfddly[1] fz_pfddly[0] fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] fz_spare[4] fz_spare[3] fz_spare[2] fz_spare[1] fz_spare[0] fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] fz_tight_loopb fz_vcosel fz_vcotrim[10] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] dmfix_synopsys_unconnected_37 dmfix_synopsys_unconnected_38 dmfix_synopsys_unconnected_39 dmfix_synopsys_unconnected_40 dmfix_synopsys_unconnected_33 dmfix_synopsys_unconnected_36 dmfix_synopsys_unconnected_34 dmfix_synopsys_unconnected_35 dmfix_synopsys_unconnected_19 ldo_enable lock_detector__rawlockxxnnnl lock_timer__locktimecntxxnnnh[11] lock_timer__locktimecntxxnnnh[10] lock_timer__locktimecntxxnnnh[9] lock_timer__locktimecntxxnnnh[8] lock_timer__locktimecntxxnnnh[7] lock_timer__locktimecntxxnnnh[6] lock_timer__locktimecntxxnnnh[5] lock_timer__locktimecntxxnnnh[4] lock_timer__locktimecntxxnnnh[3] lock_timer__locktimecntxxnnnh[2] lock_timer__locktimecntxxnnnh[1] lock_timer__locktimecntxxnnnh[0] lockxxnnnl mash__halfintmxh tap_out[43] mash__ratiomxh[8] mash__ratiomxh[7] mash__ratiomxh[6] mash__ratiomxh[5] mash__ratiomxh[4] mash__ratiomxh[3] mash__ratiomxh[2] mash__ratiomxh[1] mash__ratiomxh[0] mash_order_plus_one mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] p_abuf10 p_abuf11 p_abuf12 p_abuf13 p_abuf14 p_abuf15 p_abuf16 p_abuf17 p_abuf18 p_abuf19 p_abuf20 p_abuf21 p_abuf22 p_abuf23 p_abuf24 p_abuf25 p_abuf26 p_aps0 p_aps1 plldistpwrgoodnnnnh rationnnnh[9] rationnnnh[8] rationnnnh[7] rationnnnh[6] rationnnnh[5] rationnnnh[4] rationnnnh[3] rationnnnh[2] rationnnnh[1] rationnnnh[0] dmfix_synopsys_unconnected_27 dmfix_synopsys_unconnected_29 reset_b_nnnnh reset_sync__reset_b_xxnnnl ssc_cyc_to_peak_m1[8] ssc_cyc_to_peak_m1[7] ssc_cyc_to_peak_m1[6] ssc_cyc_to_peak_m1[5] ssc_cyc_to_peak_m1[4] ssc_cyc_to_peak_m1[3] ssc_cyc_to_peak_m1[2] ssc_cyc_to_peak_m1[1] ssc_cyc_to_peak_m1[0] ssc_en ssc_frac_step[23] ssc_frac_step[22] ssc_frac_step[21] ssc_frac_step[20] ssc_frac_step[19] ssc_frac_step[18] ssc_frac_step[17] ssc_frac_step[16] ssc_frac_step[15] ssc_frac_step[14] ssc_frac_step[13] ssc_frac_step[12] ssc_frac_step[11] ssc_frac_step[10] ssc_frac_step[9] ssc_frac_step[8] ssc_frac_step[7] ssc_frac_step[6] ssc_frac_step[5] ssc_frac_step[4] ssc_frac_step[3] ssc_frac_step[2] ssc_frac_step[1] ssc_frac_step[0] ssc_mod_dfx__modulatorennh ssc_mod_dfx__triggerregxdh startup_gen__pfdenxxh tap_in[206] tap_in[205] tap_in[204] tap_in[203] tap_in[202] tap_in[201] tap_in[200] tap_in[199] tap_in[198] tap_in[197] tap_in[196] tap_in[195] tap_in[194] tap_in[193] tap_in[192] tap_in[191] tap_in[190] tap_in[189] tap_in[188] tap_in[187] tap_in[186] tap_in[185] tap_in[184] tap_in[183] tap_in[182] tap_in[181] tap_in[180] tap_in[179] tap_in[178] tap_in[177] tap_in[176] tap_in[175] tap_in[174] tap_in[173] tap_in[172] tap_in[171] tap_in[170] tap_in[169] tap_in[168] tap_in[167] tap_in[166] tap_in[165] tap_in[164] tap_in[163] tap_in[162] tap_in[161] tap_in[160] tap_in[159] tap_in[158] tap_in[157] tap_in[156] tap_in[155] tap_in[154] tap_in[153] tap_in[152] tap_in[151] tap_in[150] tap_in[149] tap_in[148] tap_in[147] tap_in[146] tap_in[145] tap_in[144] tap_in[143] tap_in[142] tap_in[141] tap_in[140] tap_in[139] tap_in[138] tap_in[137] tap_in[136] tap_in[135] tap_in[134] tap_in[133] tap_in[132] tap_in[131] tap_in[130] dmfix_synopsys_unconnected_14 dmfix_synopsys_unconnected_15 dmfix_synopsys_unconnected_16 tap_in[126] tap_in[125] tap_in[124] tap_in[123] tap_in[122] tap_in[121] tap_in[120] tap_in[119] tap_in[118] tap_in[117] tap_in[116] tap_in[115] tap_in[114] tap_in[113] tap_in[112] tap_in[111] tap_in[110] tap_in[109] tap_in[108] tap_in[107] tap_in[106] tap_in[105] dmfix_synopsys_unconnected_17 tap_in[103] tap_in[102] tap_in[101] tap_in[100] tap_in[99] tap_in[98] tap_in[97] tap_in[96] tap_in[95] tap_in[94] tap_in[93] tap_in[92] tap_in[91] tap_in[90] tap_in[89] tap_in[88] tap_in[87] tap_in[86] tap_in[85] tap_in[84] tap_in[83] tap_in[82] tap_in[81] tap_in[80] tap_in[79] tap_in[78] tap_in[77] tap_in[76] tap_in[75] tap_in[74] tap_in[73] tap_in[72] tap_in[71] tap_in[70] tap_in[69] tap_in[68] tap_in[67] tap_in[66] tap_in[65] tap_in[64] tap_in[63] tap_in[62] tap_in[61] tap_in[60] tap_in[59] tap_in[58] tap_in[57] tap_in[56] tap_in[55] tap_in[54] tap_in[53] tap_in[52] tap_in[51] tap_in[50] tap_in[49] tap_in[48] tap_in[47] tap_in[46] tap_in[45] tap_in[44] tap_in[43] tap_in[42] tap_in[41] tap_in[40] tap_in[39] tap_in[38] tap_in[37] tap_in[36] tap_in[35] tap_in[34] tap_in[33] tap_in[32] tap_in[31] tap_in[30] tap_in[29] tap_in[28] tap_in[27] tap_in[26] tap_in[25] tap_in[24] tap_in[23] tap_in[22] tap_in[21] tap_in[20] tap_in[19] tap_in[18] tap_in[17] tap_in[16] tap_in[15] tap_in[14] tap_in[13] tap_in[12] tap_in[11] tap_in[10] tap_in[9] tap_in[8] tap_in[7] tap_in[6] tap_in[5] tap_in[4] tap_in[3] tap_in[2] tap_in[1] tap_in[0] tap_out[61] tap_out[60] dmfix_synopsys_unconnected_18 tap_out[58] tap_out[57] tap_out[56] tap_out[55] tap_out[54] tap_out[53] tap_out[52] tap_out[51] tap_out[50] tap_out[49] tap_out[48] tap_out[47] tap_out[46] tap_out[45] tap_out[44] mash__ratiomxh[9] tap_out[42] tap_out[41] tap_out[40] tap_out[39] tap_out[38] tap_out[37] tap_out[36] tap_out[35] tap_out[34] tap_out[33] tap_out[32] tap_out[31] tap_out[30] tap_out[29] tap_out[28] tap_out[27] tap_out[26] tap_out[25] tap_out[24] tap_out[23] tap_out[22] tap_out[21] tap_out[20] tap_out[19] tap_out[18] tap_out[17] tap_out[16] tap_out[15] tap_out[14] tap_out[13] tap_out[12] tap_out[11] tap_out[10] tap_out[9] tap_out[8] tap_out[7] tap_out[6] tap_out[5] tap_out[4] tap_out[3] tap_out[2] tap_out[1] tap_out[0] tlctrl_sip__statexxnnnh[1] tlctrl_sip__statexxnnnh[0] test_so3 unlock_counter__unlockcountxxnnnh_0 vcodiv_ratio[1] vcodiv_ratio[0] vdd view_adc__dig_out[9] view_adc__dig_out[8] view_adc__dig_out[7] view_adc__dig_out[6] view_adc__dig_out[5] view_adc__dig_out[4] view_adc__dig_out[3] view_adc__dig_out[2] view_adc__dig_out[1] view_adc__dig_out[0] view_adc__done viewout_cnt[14] viewout_cnt[13] viewout_cnt[12] viewout_cnt[11] viewout_cnt[10] viewout_cnt[9] viewout_cnt[8] viewout_cnt[7] viewout_cnt[6] viewout_cnt[5] viewout_cnt[4] viewout_cnt[3] viewout_cnt[2] viewout_cnt[1] viewout_cnt[0] dmfix_synopsys_unconnected_30 dmfix_synopsys_unconnected_31 vssx zdiv0_ratio[9] zdiv0_ratio[8] zdiv0_ratio[7] zdiv0_ratio[6] zdiv0_ratio[5] zdiv0_ratio[4] zdiv0_ratio[3] zdiv0_ratio[2] zdiv0_ratio[1] zdiv0_ratio[0] zdiv0_ratio_p5 zdiv1_ratio[9] zdiv1_ratio[8] zdiv1_ratio[7] zdiv1_ratio[6] zdiv1_ratio[5] zdiv1_ratio[4] zdiv1_ratio[3] zdiv1_ratio[2] zdiv1_ratio[1] zdiv1_ratio[0] zdiv1_ratio_p5 ringpll__ljpll_dfx
Xidv_fub clkidvih idv_fub__idvaddrth[9] idv_fub__idvaddrth[8] idv_fub__idvaddrth[7] idv_fub__idvaddrth[6] idv_fub__idvaddrth[5] idv_fub__idvaddrth[4] idv_fub__idvaddrth[3] idv_fub__idvaddrth[2] idv_fub__idvaddrth[1] idv_fub__idvaddrth[0] idv_fub__idvdisableth idv_fub__idvgateennh idvdisable_bi idvdisable_bo idvfreqai idvfreqao idvfreqbi idvfreqbo idvpulsei idvpulseo idvtclki idvtctrli idvtctrlo idvtdi idvtdo idvtresi idvtreso p_abuf41 vdd vssx ringpll__idv_fublet
Xidv dfx__openloop n17 n36 n37 n38 n39 n40 n41 idv_fub__idvaddrth[9] idv_fub__idvaddrth[8] idv_fub__idvaddrth[7] idv_fub__idvaddrth[6] idv_fub__idvaddrth[5] idv_fub__idvaddrth[4] idv_fub__idvaddrth[3] idv_fub__idvaddrth[2] idv_fub__idvaddrth[1] idv_fub__idvaddrth[0] idv_fub__idvdisableth idv__rdacctlth_pre[3] idv__rdacctlth_pre[2] idv__rdacctlth_pre[1] idv__rdacctlth_pre[0] idv__cbctlth[2] idv__cbctlth[1] idv__cbctlth[0] idv__pgctlth[3] idv__pgctlth[2] idv__pgctlth[1] idv__pgctlth[0] vdd vssx ringpll__ljpll_idv
Xtlctrl_sip clkrefxxh reset_sync__reset_b_xxnnnl dfx__tllm_en lock_detector__earlylockxxnnnh tlctrl_sip__lockrstxxnnnh_pre tlctrl_sip__statexxnnnh_pre[1] tlctrl_sip__statexxnnnh_pre[0] tlctrl_sip__tightloopxxnnnh_pre dmfix_synopsys_unconnected_71 tlctrl_sip__earlylockxxnnnh idfx_fscan_clkungate n65 n64 p_abuf7 vdd vssx p_abuf6 p_abuf44 ringpll__tlctrl_sip
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22_cnlx74ljpllpwrgatepfd
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22_cnlx74ljpllpwrgatepfd cpenable lockreset pumpdn pumpup tup chopen disablepfdpwrgate fbkclkin lockthresh[3] lockthresh[2] lockthresh[1] pfden pgatedlytrim[1] pgatedlytrim[0] refclkin respul[2] respul[1] respul[0] vccxx vssx
* .PININFO chopen:I disablepfdpwrgate:I fbkclkin:I lockthresh[3]:I lockthresh[2]:I lockthresh[1]:I pfden:I pgatedlytrim[1]:I pgatedlytrim[0]:I
* .PININFO refclkin:I respul[2]:I respul[1]:I respul[0]:I vccxx:I vssx:I cpenable:O lockreset:O pumpdn:O pumpup:O tup:O
Xfanen pwrgatecpen vccxx vssx reforfbk softhigh dlydpfdreset_b ringpll__pllx22_b15fan003xn1n02x5
Xiresd dlydpfdreset pfdresetb respul[2] respul[1] respul[0] vccxx vssx ringpll__pllx22_cnlx74ljpllresidualdly
Xilockresetgen lockreset dn lockthresh[3] lockthresh[2] lockthresh[1] up vccxx vssx ringpll__pllx22_cnlx74ljpllpfdlockrstgen
Xrefclkdly dlyrefclk refclkin pgdly0 pgdly1 vccxx vssx ringpll__pllx22ljpllpfdclkdly
Xfbkclkdly dlyfbkclk fbkclkin pgdly0 pgdly1 vccxx vssx ringpll__pllx22ljpllpfdclkdly
Xfandn dn vccxx vssx dlyfbkclk softhigh dlydpfdreset_b ringpll__pllx22_b15fan003xn1n08x5
Xfanup up vccxx vssx dlyrefclk softhigh dlydpfdreset_b ringpll__pllx22_b15fan003xn1n08x5
Xfan00 tup vccxx vssx trefclk td pfdeni ringpll__pllx22_b15fan003xn1n08x5
Xinv07 up_b pumpup vccxx vssx ringpll__b15inv000an1n08x5 m=1
Xinv04 dn_b pumpdn vccxx vssx ringpll__b15inv000an1n08x5 m=1
Xbfm21 cpenb_buf1 cpenb_buf2 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xbfm20 cpen_b cpenb_buf1 vccxx vssx ringpll__b15bfm201an1n04x5 m=1
Xnor00 pwrgatecpen disablepfdpwrgate cpen_b vccxx vssx ringpll__b15nor002an1n03x5 m=1
Xinv00 vssx softhigh vccxx vssx ringpll__b15inv000al1n05x5 m=1
Xinvpfden pfden pfdenb vccxx vssx ringpll__b15inv000al1n05x5 m=1
Xinaxa dn up pfdresetb vccxx vssx ringpll__b15nand02an1n08x5 m=1
Xcbf01 dlyfbkclk nc1 vccxx vssx ringpll__b15cbf000an1n02x5 m=1
Xcbf00 dlyrefclk trefclk vccxx vssx ringpll__b15cbf000an1n02x5 m=1
Xnor01 dlydpfdreset pfdenb dlydpfdreset_b vccxx vssx ringpll__b15nor002an1n12x5 m=1
Xinv01 pfdenb pfdeni vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv03 cpenb_buf2 cpenable vccxx vssx ringpll__b15inv000an1n05x5 m=1
Xbfm41 dn nc2 vccxx vssx ringpll__b15bfm402an1n02x5 m=1
Xbfm40 up td vccxx vssx ringpll__b15bfm402an1n02x5 m=1
Xnand1 chopen lockreset chop vccxx vssx ringpll__b15nand02an1n03x5 m=1
Xnanb1 chop dn dn_b vccxx vssx ringpll__b15nand02an1n03x5 m=1
Xnanb0 chop up up_b vccxx vssx ringpll__b15nand02an1n03x5 m=1
Xpgctl pgdly0 pgdly1 reforfbk disablepfdpwrgate fbkclkin pgatedlytrim[1] pgatedlytrim[0] refclkin vccxx vssx ringpll__pllx22_cnlx74ljpllpgatepfdctrl
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_clkdiv_syncrst_div0
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_clkdiv_syncrst_div0 clkout divbygt1 clkin enb rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 vccxx vssx rstb
* .PININFO clkin:I enb:I rat0p5:I rat[9]:I rat[8]:I rat[7]:I rat[6]:I rat[5]:I rat[4]:I rat[3]:I rat[2]:I rat[1]:I rat[0]:I rstb:I vccxx:I vssx:I
* .PININFO clkout:O divbygt1:O
Xinv04 reset_sync_b2 rst vccxx vssx ringpll__b15inv000al1n08x5 m=1
Xornc1 rat[4] rat[3] rat[2] rat[1] n2 vccxx vssx ringpll__b15ornc04al1n02x5 m=1
Xornc0 rat[8] rat[7] rat[6] rat[5] n1 vccxx vssx ringpll__b15ornc04al1n02x5 m=1
Xnor01 enbi rat[9] n1 n2 divby0or1 vccxx vssx ringpll__b15nor004al1n04x5 m=1
Xinv01 divby0or1 divbygt1 vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinv03 enb en vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv02 en enbi vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xand01 en divbygt1 endivclk vccxx vssx ringpll__b15and002al1n02x5 m=1
Xclb00 clkin clktodiv endivclk vccxx vssx ringpll__b15clb0a2ah1n06x5 m=1
Xmbn00 clkin clkdiv clkout divby1 vccxx vssx ringpll__b15cmbn22ah1n12x5 m=1
Xand00 rat[0] divby0or1 divby1 vccxx vssx ringpll__b15and002al1n03x5 m=1
Xfmy20 clkin en reset_sync_b rstb vccxx vccxx vccxx vssx ringpll__b15fmy203al1n04x5 m=1
Xidiv clkdiv clktodiv rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 rst vccxx vssx ringpll__cpafdivtop_pllclk
Xbfm21 reset_sync_b1 reset_sync_b2 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xbfm20 reset_sync_b reset_sync_b1 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_clkdiv_syncrst_div1
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_clkdiv_syncrst_div1 clkout divbygt1 clkin enb rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 rstb vccxx vssx
* .PININFO clkin:I enb:I rat0p5:I rat[9]:I rat[8]:I rat[7]:I rat[6]:I rat[5]:I rat[4]:I rat[3]:I rat[2]:I rat[1]:I rat[0]:I rstb:I vccxx:I vssx:I
* .PININFO clkout:O divbygt1:O
Xbfm21 reset_sync_b1 reset_sync_b2 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xbfm20 reset_sync_b reset_sync_b1 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xornc1 rat[4] rat[3] rat[2] rat[1] n2 vccxx vssx ringpll__b15ornc04al1n02x5 m=1
Xornc0 rat[8] rat[7] rat[6] rat[5] n1 vccxx vssx ringpll__b15ornc04al1n02x5 m=1
Xnor01 enbi rat[9] n1 n2 divby0or1 vccxx vssx ringpll__b15nor004al1n04x5 m=1
Xinv01 divby0or1 divbygt1 vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinv03 enb en vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv02 en enbi vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xand01 en divbygt1 endivclk vccxx vssx ringpll__b15and002al1n02x5 m=1
Xclb00 clkin clktodiv endivclk vccxx vssx ringpll__b15clb0a2ah1n06x5 m=1
Xmbn00 clkin clkdiv clkout divby1 vccxx vssx ringpll__b15cmbn22ah1n12x5 m=1
Xand00 rat[0] divby0or1 divby1 vccxx vssx ringpll__b15and002al1n03x5 m=1
Xfmy20 clkin en reset_sync_b rstb vccxx vccxx vccxx vssx ringpll__b15fmy203al1n04x5 m=1
Xidiv clkdiv clktodiv rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 rst vccxx vssx ringpll__cpafdivtop_pllclk
Xinv04 reset_sync_b2 rst vccxx vssx ringpll__b15inv000al1n08x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_clkdiv
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_clkdiv clkout divbygt1 clkin enb rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 vccxx vssx rstb
* .PININFO clkin:I enb:I rat0p5:I rat[9]:I rat[8]:I rat[7]:I rat[6]:I rat[5]:I rat[4]:I rat[3]:I rat[2]:I rat[1]:I rat[0]:I rstb:I vccxx:I vssx:I
* .PININFO clkout:O divbygt1:O
Xidiv clkdiv clktodiv rat[9] rat[8] rat[7] rat[6] rat[5] rat[4] rat[3] rat[2] rat[1] rat[0] rat0p5 rst vccxx vssx ringpll__cpafdivtop
Xornc1 rat[4] rat[3] rat[2] rat[1] n2 vccxx vssx ringpll__b15ornc04al1n02x5 m=1
Xornc0 rat[8] rat[7] rat[6] rat[5] n1 vccxx vssx ringpll__b15ornc04al1n02x5 m=1
Xnor01 enbi rat[9] n1 n2 divby0or1 vccxx vssx ringpll__b15nor004al1n04x5 m=1
Xinv00 rstb rst vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinv01 divby0or1 divbygt1 vccxx vssx ringpll__b15inv000al1n03x5 m=1
Xinv03 enb en vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xinv02 en enbi vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xand01 en divbygt1 endivclk vccxx vssx ringpll__b15and002al1n02x5 m=1
Xclb00 clkin clktodiv endivclk vccxx vssx ringpll__b15clb0a2ah1n06x5 m=1
Xmbn00 clkin clkdiv clkout divby1 vccxx vssx ringpll__b15cmbn22ah1n12x5 m=1
Xand00 rat[0] divby0or1 divby1 vccxx vssx ringpll__b15and002al1n03x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljplldac_res_logic
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljplldac_res_logic enn tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 pon vccxx vssx
* .PININFO pon:I vccxx:I vssx:I enn:O tap0:B tap1:B tap2:B tap3:B tap4:B tap5:B tap6:B tap7:B tap8:B tap9:B tap10:B tap11:B tap12:B tap13:B tap14:B
* .PININFO tap15:B
Xreslad bot vccxx tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 top ringpll__pllx22ljplldac_res
Xinv01 xxxss enn vccxx vssx ringpll__b15inv000al1n08x5 m=1
Xinv00 pon xxxss vccxx vssx ringpll__b15inv000al1n08x5 m=1
Mmp0[5] top xxxss vccxx vccxx plp W=225n L=40n M=1
Mmp0[4] top xxxss vccxx vccxx plp W=225n L=40n M=1
Mmp0[3] top xxxss vccxx vccxx plp W=225n L=40n M=1
Mmp0[2] top xxxss vccxx vccxx plp W=225n L=40n M=1
Mmp0[1] top xxxss vccxx vccxx plp W=225n L=40n M=1
Mmn0[10] bot enn vssx vssx nlp W=180n L=40n M=1
Mmn0[9] bot enn vssx vssx nlp W=180n L=40n M=1
Mmn0[8] bot enn vssx vssx nlp W=180n L=40n M=1
Mmn0[7] bot enn vssx vssx nlp W=180n L=40n M=1
Mmn0[6] bot enn vssx vssx nlp W=180n L=40n M=1
Mmn0[5] bot enn vssx vssx nlp W=180n L=40n M=1
Mmn0[4] bot enn vssx vssx nlp W=180n L=40n M=1
Mmn0[3] bot enn vssx vssx nlp W=180n L=40n M=1
Mmn0[2] bot enn vssx vssx nlp W=180n L=40n M=1
Mmn0[1] bot enn vssx vssx nlp W=180n L=40n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_dca2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_dca2 clkout cb[1] cb[0] clkin ctrl[5] ctrl[4] ctrl[3] ctrl[2] ctrl[1] ctrl[0] vccxx vssx
* .PININFO cb[1]:I cb[0]:I clkin:I ctrl[5]:I ctrl[4]:I ctrl[3]:I ctrl[2]:I ctrl[1]:I ctrl[0]:I vccxx:I vssx:I clkout:O
Xnand12 clkb vccxx vssx clkin en_dca ringpll__pll_clknand
Xcmbn0 clkdca clkin clkout en_dca vccxx vssx ringpll__b15cmbn22ah1n16x5 m=1
Xnor00 ctrl[5] ctrl[4] ctrl[3] n1 vccxx vssx ringpll__b15nor003al1n02x3 m=1
Xnor01 ctrl[2] ctrl[1] ctrl[0] n2 vccxx vssx ringpll__b15nor003al1n02x3 m=1
Xnand0 n1 n2 en_dca vccxx vssx ringpll__b15nand02al1n04x5 m=1
Xcinv2 clkb clk2dca vccxx vssx ringpll__b15cinv00ah1n16x5 m=1
Xidcatop clkdca cb[1] cb[0] clk2dca ctrl[5] ctrl[4] ctrl[3] ctrl[2] ctrl[1] ctrl[0] vccxx vssx ringpll__pll1_dcatop
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_digtop
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_digtop ckdigoutvalu2n00 digoutu700h[9] digoutu700h[8] digoutu700h[7] digoutu700h[6] digoutu700h[5] digoutu700h[4] digoutu700h[3] digoutu700h[2] digoutu700h[1] digoutu700h[0] done cksdclk ioff_b sdmodout vccxx vssx
* .PININFO cksdclk:I ioff_b:I sdmodout:I vccxx:I vssx:I ckdigoutvalu2n00:O digoutu700h[9]:O digoutu700h[8]:O digoutu700h[7]:O digoutu700h[6]:O
* .PININFO digoutu700h[5]:O digoutu700h[4]:O digoutu700h[3]:O digoutu700h[2]:O digoutu700h[1]:O digoutu700h[0]:O done:O
Xi53_1 cksdclk cksdclkph2 vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xi50 cntrload cntrload_b_dly vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xinv00 cntrwrap_b cntrload vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xinv01 net8 net18 vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xbfn02 net28 net27 vccxx vssx ringpll__b15bfn000al1n02x5 m=1
Xi68 ioff_b_dly cntrload net8 vccxx vssx ringpll__b15and002al1n04x5 m=1
Xand01 cksdclk net27 ckcntrenph1 vccxx vssx ringpll__b15and002al1n04x5 m=1
Xlan0 cksdclk net18 net28 vccxx vssx ringpll__b15lsn080al1n04x5 m=1
Xbfn00 ioff_b ioff_b_dly vccxx vssx ringpll__b15bfn000al1n08x5 m=1
Xi48 vssx hi vccxx vssx ringpll__b15inv000al1n04x5 m=1
Xfsn0 cksdclk net8 done vccxx vssx ringpll__b15fpn000al1n08x5 m=1
Xand02 cksdclkph2 cntrload ckdigoutvalu2n00 vccxx vssx ringpll__b15and002al1n08x5 m=1
Xix10thmprimcntr cntrwrap_b ncdigout[9] ncdigout[8] ncdigout[7] ncdigout[6] ncdigout[5] ncdigout[4] ncdigout[3] ncdigout[2] ncdigout[1] ncdigout[0] ckcntrenph1 hi hi ioff_b_dly vccxx vssx ringpll__adc_inc
Xix10thmsdcntr nc11 digoutu700h[9] digoutu700h[8] digoutu700h[7] digoutu700h[6] digoutu700h[5] digoutu700h[4] digoutu700h[3] digoutu700h[2] digoutu700h[1] digoutu700h[0] ckcntrenph1 sdmodout cntrload_b_dly ioff_b_dly vccxx vssx ringpll__adc_inc
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_fbgen_b0
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_fbgen_b0 clkfb clkfb2 pll_fbgen_tight_loop clkpll clkpostdist idv_gate_en pfden ratio[9] ratio[8] ratio[7] ratio[6] ratio[5] ratio[4] ratio[3] ratio[2] ratio[1] ratio[0] ratio_halfint reset_b tight_loop tlctrl_gategridclkb tlctrl_tightloopb vccpll vssx
* .PININFO clkpll:I clkpostdist:I idv_gate_en:I pfden:I ratio[9]:I ratio[8]:I ratio[7]:I ratio[6]:I ratio[5]:I ratio[4]:I ratio[3]:I ratio[2]:I
* .PININFO ratio[1]:I ratio[0]:I ratio_halfint:I reset_b:I tight_loop:I tlctrl_gategridclkb:I tlctrl_tightloopb:I vccpll:I vssx:I clkfb:O clkfb2:O
* .PININFO pll_fbgen_tight_loop:O
Xfpy00[10] clkfb_buf ri[9] ratiosampled[9] vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xfpy00[9] clkfb_buf ri[8] ratiosampled[8] vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xfpy00[8] clkfb_buf ri[7] ratiosampled[7] vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xfpy00[7] clkfb_buf ri[6] ratiosampled[6] vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xfpy00[6] clkfb_buf ri[5] ratiosampled[5] vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xfpy00[5] clkfb_buf ri[4] ratiosampled[4] vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xfpy00[4] clkfb_buf ri[3] ratiosampled[3] vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xfpy00[3] clkfb_buf ri[2] ratiosampled[2] vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xfpy00[2] clkfb_buf ri[1] ratiosampled[1] vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xfpy00[1] clkfb_buf ri[0] ratiosampled[0] vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xfpy00[0] clkfb_buf hfi halfintsampled vccpll vccpll vccpll vssx ringpll__b15fpy000al1n02x5 m=1
Xmbn00[10] ratiosampled[9] ri[9] ratio2fbdiv[9] selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xmbn00[9] ratiosampled[8] ri[8] ratio2fbdiv[8] selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xmbn00[8] ratiosampled[7] ri[7] ratio2fbdiv[7] selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xmbn00[7] ratiosampled[6] ri[6] ratio2fbdiv[6] selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xmbn00[6] ratiosampled[5] ri[5] ratio2fbdiv[5] selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xmbn00[5] ratiosampled[4] ri[4] ratio2fbdiv[4] selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xmbn00[4] ratiosampled[3] ri[3] ratio2fbdiv[3] selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xmbn00[3] ratiosampled[2] ri[2] ratio2fbdiv[2] selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xmbn00[2] ratiosampled[1] ri[1] ratio2fbdiv[1] selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xmbn00[1] ratiosampled[0] ri[0] ratio2fbdiv[0] selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xmbn00[0] halfintsampled hfi halfint2fbdiv selratiosampled vccpll vssx ringpll__b15mbn022al1n02x5 m=1
Xcbf01 clkfbi clkfb_buf vccpll vssx ringpll__b15cbf000al1n06x5 m=1
Xbfn02[10] ratio[9] ri[9] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn02[9] ratio[8] ri[8] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn02[8] ratio[7] ri[7] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn02[7] ratio[6] ri[6] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn02[6] ratio[5] ri[5] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn02[5] ratio[4] ri[4] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn02[4] ratio[3] ri[3] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn02[3] ratio[2] ri[2] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn02[2] ratio[1] ri[1] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn02[1] ratio[0] ri[0] vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn02[0] ratio_halfint hfi vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xbfn00 tlmuxsel pll_fbgen_tight_loop vccpll vssx ringpll__b15bfn000al1n04x5 m=1
Xcbf02 clkfbi clkfb2 vccpll vssx ringpll__b15cbf000al1n12x5 m=1
Xcbf00 clkfbi clkfb vccpll vssx ringpll__b15cbf000al1n12x5 m=1
Xfmy21 clkfb_buf vccpll selratiosampled pfden vccpll vccpll vccpll vssx ringpll__b15fmy203al1n04x5 m=1
Xfmy20 pll_fbgen_clkpllfdivmh n21 n1 reset_b vccpll vccpll vccpll vssx ringpll__b15fmy203al1n04x5 m=1
Xclb00 clkpostdist clkpostgated tlctrl_gategridclkb vccpll vssx ringpll__b15clb0a2al1n06x5 m=1
Xorn00 pfden idv_gate_en n21 vccpll vssx ringpll__b15orn002al1n02x5 m=1
Xnanb0 tight_loop tlctrl_tightloopb tlmuxsel vccpll vssx ringpll__b15nanb02al1n16x5 m=1
Xinv00 n1 n2 vccpll vssx ringpll__b15inv000al1n04x5 m=1
Xcmbn0 clkpll clkpostgated pll_fbgen_clkpllfdivmh tlmuxsel vccpll vssx ringpll__b15cmbn22al1n08x5 m=1
Xifbdiv clkfbi pll_fbgen_clkpllfdivmh ratio2fbdiv[9] ratio2fbdiv[8] ratio2fbdiv[7] ratio2fbdiv[6] ratio2fbdiv[5] ratio2fbdiv[4] ratio2fbdiv[3] ratio2fbdiv[2] ratio2fbdiv[1] ratio2fbdiv[0] halfint2fbdiv fdiv_rst vccpll vssx ringpll__cpafdivtop_pllclk
Xbfm42 n2 fdiv_rst vccpll vssx ringpll__b15bfm402al1n16x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22ldo_nvcontrol
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22ldo_nvcontrol pon_byp start_pulse d_fast_start_i d_ldo_bypass_i d_ldo_pon_i d_refclk_i vcc_nom vssx
* .PININFO d_fast_start_i:I d_ldo_bypass_i:I d_ldo_pon_i:I d_refclk_i:I vcc_nom:I vssx:I pon_byp:O start_pulse:O
Xinv07 pon_byp vcc_nom vssx pon_byp_b ringpll__xb15inv000xl1n05x5
Xinv05 start_pulse vcc_nom vssx start_pulse_b ringpll__xb15inv000xl1n05x5
Xinv06 byp_b vcc_nom vssx d_ldo_bypass_i ringpll__xb15inv000xl1n05x5
Xinv04 pulse_en vcc_nom vssx pulse_en_b ringpll__xb15inv000xl1n05x5
Xnand3 pon_byp_b vcc_nom vssx d_ldo_pon_i byp_b ringpll__xb15nand02xl1n12x5
Xnand2 start_pulse_b vcc_nom vssx start_pulse_nobyp byp_b ringpll__xb15nand02xl1n12x5
Xnand0 pulse_en_b vcc_nom vssx d_ldo_pon_i d_fast_start_i ringpll__xb15nand02xl1n12x5
Xnand1 refclk_b vcc_nom vssx d_fast_start_i d_refclk_i ringpll__xb15nand02xl1n12x5
Xipulsegen start_pulse_nobyp refclk_b pulse_en vcc_nom vssx ringpll__x22lpldo_pulsegen_2
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22ldo_pll_bias_highcurrent
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22ldo_pll_bias_highcurrent ibias_1u bypass en_hicurrent p_on vddh vref_0v6_in vssx
* .PININFO bypass:I en_hicurrent:I p_on:I vddh:I vref_0v6_in:I vssx:I ibias_1u:B
Xi82 biasres_mid n1 vssx ringpll__x22ldo_pll_20k_res
Xi40 res4 res3 vssx ringpll__x22ldo_pll_20k_res
Xi81 nsource biasres_mid vssx ringpll__x22ldo_pll_20k_res
Xnand0 en_hicurr_b vddh vssx pu en_hicurrent ringpll__xb15nand02xu1n12x5
Xu1772 pd vddh vssx p_on n4 ringpll__xb15nand02xu1n12x5
Xi27 res1 vssx vssx ringpll__x22ldo_pll_40k_res
Xi41 res3 res2 vssx ringpll__x22ldo_pll_40k_res
Xi19 res2 res1 vssx ringpll__x22ldo_pll_40k_res
Xstkp3_dummy[3] vddh vddh ibias_1u vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp3_dummy[2] vddh vddh ibias_1u vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp3_dummy[1] vddh vddh ibias_1u vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp3[3] vddh outn ibias_1u vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp3[2] vddh outn ibias_1u vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp3[1] vddh outn ibias_1u vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[12] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[11] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[10] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[9] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[8] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[7] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[6] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[5] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[4] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[3] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[2] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp2[1] vddh outn ibfb vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp0[8] vddh outp outp vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp0[7] vddh outp outp vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp0[6] vddh outp outp vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp0[5] vddh outp outp vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp0[4] vddh outp outp vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp0[3] vddh outp outp vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp0[2] vddh outp outp vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp0[1] vddh outp outp vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp1[8] vddh outp outn vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp1[7] vddh outp outn vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp1[6] vddh outp outn vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp1[5] vddh outp outn vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp1[4] vddh outp outn vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp1[3] vddh outp outn vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp1[2] vddh outp outn vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xstkp1[1] vddh outp outn vddh ringpll__x22imc_ana_p144_mult1_4dg_5stack
Xicompcap2 comp ibfb nc2 nc1 vssx ringpll__mfc_s2s_pcell_8
Xicompres outn comp vssx ringpll__x22heldo_res_10k
Xi69 ibfb res4 vssx ringpll__x22heldo_res_10k
Xinv01 en_hicurr vddh vssx en_hicurr_b ringpll__xb15inv000xu1n05x5
Xu1035 n4 vddh vssx bypass ringpll__xb15inv000xu1n05x5
Xinv00 pu vddh vssx pd ringpll__xb15inv000xu1n05x5
Mqn1[3] res3 en_hicurr vssx vssx ntgmv W=180n L=120n M=1
Mqn1[2] res3 en_hicurr vssx vssx ntgmv W=180n L=120n M=1
Mqn1[1] res3 en_hicurr vssx vssx ntgmv W=180n L=120n M=1
Mqn0[3] biasres_mid en_hicurr vssx vssx ntgmv W=180n L=120n M=1
Mqn0[2] biasres_mid en_hicurr vssx vssx ntgmv W=180n L=120n M=1
Mqn0[1] biasres_mid en_hicurr vssx vssx ntgmv W=180n L=120n M=1
Mncs[3] n1 pu vssx vssx ntgmv W=180n L=120n M=1
Mncs[2] n1 pu vssx vssx ntgmv W=180n L=120n M=1
Mncs[1] n1 pu vssx vssx ntgmv W=180n L=120n M=1
Xstkn0_dummy[2] outn vssx vssx vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0_dummy[1] outn vssx vssx vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1_dummy[2] outp vssx vssx vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1_dummy[1] outp vssx vssx vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0[10] outn vref_0v6_in nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0[9] outn vref_0v6_in nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0[8] outn vref_0v6_in nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0[7] outn vref_0v6_in nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0[6] outn vref_0v6_in nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0[5] outn vref_0v6_in nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0[4] outn vref_0v6_in nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0[3] outn vref_0v6_in nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0[2] outn vref_0v6_in nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn0[1] outn vref_0v6_in nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1[10] outp ibfb nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1[9] outp ibfb nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1[8] outp ibfb nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1[7] outp ibfb nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1[6] outp ibfb nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1[5] outp ibfb nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1[4] outp ibfb nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1[3] outp ibfb nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1[2] outp ibfb nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Xstkn1[1] outp ibfb nsource vssx ringpll__x22imc_ana_144_mult1_4dg_5stack
Mqp0[2] outp pu vddh vddh ptgmv W=180n L=120n M=1
Mqp0[1] outp pu vddh vddh ptgmv W=180n L=120n M=1
Mqp1[2] outn pu vddh vddh ptgmv W=180n L=120n M=1
Mqp1[1] outn pu vddh vddh ptgmv W=180n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_sdmodana
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_sdmodana ckph1dfb ckph2dfb sdout chop ckph1 ckph2 en_b fdbkin vangin_a vcchv vccxx vref_a vssx
* .PININFO chop:I ckph1:I ckph2:I en_b:I fdbkin:I vangin_a:I vcchv:I vccxx:I vref_a:I vssx:I ckph1dfb:O ckph2dfb:O sdout:O
Xibiasgen vcref_a en_b_thm vccxx vssx ringpll__adc_invamp_biasgen
Xisdangcore ckph1dfb ckph2dfb en_b_thm sdout chop ckph1 ckph2 en_b fdbkin vangin_a vcref_a vcchv vccxx vref_a vssx ringpll__adc_angcoreswc
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_viewmux
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_viewmux view_mux_viewoutnnnnh[1] view_mux_viewoutnnnnh[0] clkfbmxh clkpostdistmh clkref_prediv clkrefxxh earlylockxxl lockxxl mod_clk_to_view pfdennh pll_core_clk_pll_div1 pll_fbgen_tight_loop powergood rawlockxxl reset_b ssc_reload vccpll vctlrdacennl viewdigennh[1] viewdigennh[0] viewsel0[4] viewsel0[3] viewsel0[2] viewsel0[1] viewsel0[0] viewsel1[4] viewsel1[3] viewsel1[2] viewsel1[1] viewsel1[0] vssx
* .PININFO clkfbmxh:I clkpostdistmh:I clkref_prediv:I clkrefxxh:I earlylockxxl:I lockxxl:I mod_clk_to_view:I pfdennh:I pll_core_clk_pll_div1:I
* .PININFO pll_fbgen_tight_loop:I powergood:I rawlockxxl:I reset_b:I ssc_reload:I vccpll:I vctlrdacennl:I viewdigennh[1]:I viewdigennh[0]:I
* .PININFO viewsel0[4]:I viewsel0[3]:I viewsel0[2]:I viewsel0[1]:I viewsel0[0]:I viewsel1[4]:I viewsel1[3]:I viewsel1[2]:I viewsel1[1]:I viewsel1[0]:I
* .PININFO vssx:I view_mux_viewoutnnnnh[1]:O view_mux_viewoutnnnnh[0]:O
Xorn00 viewdigennh[1] viewdigennh[0] enclks vccpll vssx ringpll__b15orn002al1n08x5 m=1
Xi71 postdiv2 postdiv4 clkpostgated enclks vccpll vssx ringpll__pll_dftdiv
Xi61 plldiv2 plldiv4 clkpllgated enclks vccpll vssx ringpll__pll_dftdiv
Xclb01 clkpostdistmh clkpostgated enclks vccpll vssx ringpll__b15clb0a2al1n06x5 m=1
Xclb00 pll_core_clk_pll_div1 clkpllgated enclks vccpll vssx ringpll__b15clb0a2al1n06x5 m=1
Ximux1 view_mux_viewoutnnnnh[1] viewdigennh[1] vssx vccpll clkrefxxh rawlockxxl clkfbmxh lockxxl pll_fbgen_tight_loop reset_b pfdennh ssc_reload powergood earlylockxxl vctlrdacennl vssx mod_clk_to_view vssx clkpostgated vssx clkpllgated vssx plldiv4 vssx plldiv2 vssx postdiv2 vssx postdiv4 vssx vssx vssx vssx clkref_prediv vccpll viewsel1[4] viewsel1[3] viewsel1[2] viewsel1[1] viewsel1[0] vssx ringpll__pll_viewmux32
Ximux0 view_mux_viewoutnnnnh[0] viewdigennh[0] vssx vccpll clkrefxxh rawlockxxl clkfbmxh lockxxl pll_fbgen_tight_loop reset_b pfdennh ssc_reload powergood earlylockxxl vctlrdacennl vssx mod_clk_to_view vssx clkpostgated vssx clkpllgated vssx plldiv4 vssx plldiv2 vssx postdiv2 vssx postdiv4 vssx vssx vssx vssx clkref_prediv vccpll viewsel0[4] viewsel0[3] viewsel0[2] viewsel0[1] viewsel0[0] vssx ringpll__pll_viewmux32
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_refgen_1v_to_0p6v
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_refgen_1v_to_0p6v vref_0p6v en_1p24v pon ref_trim[3] ref_trim[2] ref_trim[1] ref_trim[0] strong_ladder_en vcc_hv vccg vssx vref_1v
* .PININFO en_1p24v:I pon:I ref_trim[3]:I ref_trim[2]:I ref_trim[1]:I ref_trim[0]:I strong_ladder_en:I vcc_hv:I vccg:I vref_1v:I vssx:I vref_0p6v:O
Xitgate tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 strong_ladder_en tap0_boost tap1_boost tap2_boost tap3_boost tap4_boost tap5_boost tap6_boost tap7_boost tap8_boost tap9_boost tap10_boost tap11_boost tap12_boost tap13_boost tap14_boost tap15_boost vcc_hv vssx ringpll__x22heldo_fbtgate
Xiresdiv tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 en_1p24v pon vref_1v vssx ringpll__x22heldo_refresdiv_1v_to_0p6v
Xiresboost tap0_boost tap1_boost tap2_boost tap3_boost tap4_boost tap5_boost tap6_boost tap7_boost tap8_boost tap9_boost tap10_boost tap11_boost tap12_boost tap13_boost tap14_boost tap15_boost en_1p24v strong_ladder_en vref_1v vssx ringpll__x22heldo_refresdiv_1v_to_0p6v
Xifbmux vref_0p6v tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 ref_trim[3] ref_trim[2] ref_trim[1] ref_trim[0] vccg vref_1v vssx ringpll__x22heldo_fbmux_ref
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_refgen
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_refgen vref en_1p24v pon ref_trim[3] ref_trim[2] ref_trim[1] ref_trim[0] start_pulse vcc_hv vccg vssx
* .PININFO en_1p24v:I pon:I ref_trim[3]:I ref_trim[2]:I ref_trim[1]:I ref_trim[0]:I start_pulse:I vcc_hv:I vccg:I vssx:I vref:O
Xifbmux vref tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 ref_trim[3] ref_trim[2] ref_trim[1] ref_trim[0] vccg vcc_hv vssx ringpll__x22heldo_fbmux_ref
Xitgate tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 start_pulse tap0_boost tap1_boost tap2_boost tap3_boost tap4_boost tap5_boost tap6_boost tap7_boost tap8_boost tap9_boost tap10_boost tap11_boost tap12_boost tap13_boost tap14_boost tap15_boost vcc_hv vssx ringpll__x22heldo_fbtgate
Xiresdiv tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 en_1p24v pon vcc_hv vssx ringpll__x22heldo_refresdiv
Xiresboost[5] tap0_boost tap1_boost tap2_boost tap3_boost tap4_boost tap5_boost tap6_boost tap7_boost tap8_boost tap9_boost tap10_boost tap11_boost tap12_boost tap13_boost tap14_boost tap15_boost en_1p24v start_pulse vcc_hv vssx ringpll__x22heldo_refresdiv
Xiresboost[4] tap0_boost tap1_boost tap2_boost tap3_boost tap4_boost tap5_boost tap6_boost tap7_boost tap8_boost tap9_boost tap10_boost tap11_boost tap12_boost tap13_boost tap14_boost tap15_boost en_1p24v start_pulse vcc_hv vssx ringpll__x22heldo_refresdiv
Xiresboost[3] tap0_boost tap1_boost tap2_boost tap3_boost tap4_boost tap5_boost tap6_boost tap7_boost tap8_boost tap9_boost tap10_boost tap11_boost tap12_boost tap13_boost tap14_boost tap15_boost en_1p24v start_pulse vcc_hv vssx ringpll__x22heldo_refresdiv
Xiresboost[2] tap0_boost tap1_boost tap2_boost tap3_boost tap4_boost tap5_boost tap6_boost tap7_boost tap8_boost tap9_boost tap10_boost tap11_boost tap12_boost tap13_boost tap14_boost tap15_boost en_1p24v start_pulse vcc_hv vssx ringpll__x22heldo_refresdiv
Xiresboost[1] tap0_boost tap1_boost tap2_boost tap3_boost tap4_boost tap5_boost tap6_boost tap7_boost tap8_boost tap9_boost tap10_boost tap11_boost tap12_boost tap13_boost tap14_boost tap15_boost en_1p24v start_pulse vcc_hv vssx ringpll__x22heldo_refresdiv
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vcotop_lj
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vcotop_lj clkout vro cb[2] cb[1] cb[0] en pcsdegen[2] pcsdegen[1] pcsdegen[0] pgb[3] pgb[2] pgb[1] pgb[0] pvdivrat[1] pvdivrat[0] vccpll vctl vssx
* .PININFO cb[2]:I cb[1]:I cb[0]:I en:I pcsdegen[2]:I pcsdegen[1]:I pcsdegen[0]:I pgb[3]:I pgb[2]:I pgb[1]:I pgb[0]:I pvdivrat[1]:I pvdivrat[0]:I
* .PININFO vccpll:I vctl:I vssx:I clkout:O vro:O
Xipvadiv clkout clkpva pvdivrat[1] pvdivrat[0] vccpll vssx ringpll__vcopvadiv
Xivco clkvco vro cb[2] cb[1] cb[0] en pcsdegen[2] pcsdegen[1] pcsdegen[0] pgb[3] pgb[2] pgb[1] pgb[0] vccpll vctl vssx ringpll__vco_lj
Xi11 vro vssx net12 vssx ringpll__mfc_s2s_ls_pcell_120
Xi8 vro vssx net13 vssx ringpll__mfc_s2s_ls_pcell_121
Xipva clkpva clkvco en vccpll vssx ringpll__pva
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    vcotop
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__vcotop clkout vro cb[2] cb[1] cb[0] en pcsdegen[2] pcsdegen[1] pcsdegen[0] pgb[3] pgb[2] pgb[1] pgb[0] pvdivrat[1] pvdivrat[0] vccpll vctl vssx
* .PININFO cb[2]:I cb[1]:I cb[0]:I en:I pcsdegen[2]:I pcsdegen[1]:I pcsdegen[0]:I pgb[3]:I pgb[2]:I pgb[1]:I pgb[0]:I pvdivrat[1]:I pvdivrat[0]:I
* .PININFO vccpll:I vctl:I vssx:I clkout:O vro:O
Xivco clkvco vro cb[2] cb[1] cb[0] en pcsdegen[2] pcsdegen[1] pcsdegen[0] pgb[3] pgb[2] pgb[1] pgb[0] vccpll vctl vssx ringpll__vco
Xipvadiv clkout clkpva pvdivrat[1] pvdivrat[0] vccpll vssx ringpll__vcopvadiv
Xipva clkpva clkvco en vccpll vssx ringpll__pva
Xi11 vro vssx net12 vssx ringpll__mfc_s2s_ls_pcell_126
Xi8 vro vssx net13 vssx ringpll__mfc_s2s_ls_pcell_127
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    x22heldo_fbdiv
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__x22heldo_fbdiv fb fb_trim[3] fb_trim[2] fb_trim[1] fb_trim[0] vccpll vssx
* .PININFO fb_trim[3]:I fb_trim[2]:I fb_trim[1]:I fb_trim[0]:I vccpll:I vssx:I fb:O
Xifbmux fb tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 fb_trim[3] fb_trim[2] fb_trim[1] fb_trim[0] vccpll vssx ringpll__x22heldo_fbmux
Xiresdiv tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 vccpll vssx ringpll__x22heldo_resdiv_0p85
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ip22_ringpll_sip
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ip22_ringpll_sip reset_sync_bypassxxnnnl dfx_cp1_trim[4] dfx_cp1_trim[3] dfx_cp1_trim[2] dfx_cp1_trim[1] dfx_cp1_trim[0] dfx_cp2_trim[4] dfx_cp2_trim[3] dfx_cp2_trim[2] dfx_cp2_trim[1] dfx_cp2_trim[0] fz_cpnbias_a[1] fz_cpnbias_a[0] fz_dca_cb_a[1] fz_dca_cb_a[0] dfx_dca_ctrl[5] dfx_dca_ctrl[4] dfx_dca_ctrl[3] dfx_dca_ctrl[2] dfx_dca_ctrl[1] dfx_dca_ctrl[0] fz_irefgen_a[4] fz_irefgen_a[3] fz_irefgen_a[2] fz_irefgen_a[1] fz_irefgen_a[0] fz_ldo_vinvoltsel_a[1] fz_ldo_vinvoltsel_a[0] fz_ldo_bypass_a fz_ldo_extrefsel_a fz_ldo_faststart_a fz_ldo_fbtrim_a[3] fz_ldo_fbtrim_a[2] fz_ldo_fbtrim_a[1] fz_ldo_fbtrim_a[0] fz_ldo_reftrim_a[3] fz_ldo_reftrim_a[2] fz_ldo_reftrim_a[1] fz_ldo_reftrim_a[0] dfx_lockthresh[3] dfx_lockthresh[2] dfx_lockthresh[1] dfx_lockthresh[0] fz_lpfclksel_a fz_nopfdpwrgate_a fz_pfd_pw_a[2] fz_pfd_pw_a[1] fz_pfd_pw_a[0] fz_pfddly_a[1] fz_pfddly_a[0] dfx_skadj_ctrl[4] dfx_skadj_ctrl[3] dfx_skadj_ctrl[2] dfx_skadj_ctrl[1] dfx_skadj_ctrl[0] fz_spare_a[4] fz_spare_a[3] fz_spare_a[2] fz_spare_a[1] fz_spare_a[0] fz_startup_a[5] fz_startup_a[4] fz_startup_a[3] fz_startup_a[2] fz_startup_a[1] fz_startup_a[0] dfx_tight_loop fz_vcosel_a fz_vcotrim_a[10] fz_vcotrim_a[9] fz_vcotrim_a[8] fz_vcotrim_a[7] fz_vcotrim_a[6] fz_vcotrim_a[5] fz_vcotrim_a[4] fz_vcotrim_a[3] fz_vcotrim_a[2] fz_vcotrim_a[1] fz_vcotrim_a[0] idvdisable_bo idvfreqao idvfreqbo idvpulseo idvtclko idvtctrlo idvtdo idvtreso ldo_enable_a mdiv_ratio_a[5] mdiv_ratio_a[4] mdiv_ratio_a[3] mdiv_ratio_a[2] mdiv_ratio_a[1] mdiv_ratio_a[0] reset_sync_reset_b_xxnnnl mash_ratiomxh[9] mash_ratiomxh[8] mash_ratiomxh[7] mash_ratiomxh[6] mash_ratiomxh[5] mash_ratiomxh[4] mash_ratiomxh[3] mash_ratiomxh[2] mash_ratiomxh[1] mash_ratiomxh[0] mash_halfintmxh tdo vcodiv_ratio_a[1] vcodiv_ratio_a[0] zdiv0_ratio_a[9] zdiv0_ratio_a[8] zdiv0_ratio_a[7] zdiv0_ratio_a[6] zdiv0_ratio_a[5] zdiv0_ratio_a[4] zdiv0_ratio_a[3] zdiv0_ratio_a[2] zdiv0_ratio_a[1] zdiv0_ratio_a[0] zdiv0_ratio_p5_a zdiv1_ratio_a[9] zdiv1_ratio_a[8] zdiv1_ratio_a[7] zdiv1_ratio_a[6] zdiv1_ratio_a[5] zdiv1_ratio_a[4] zdiv1_ratio_a[3] zdiv1_ratio_a[2] zdiv1_ratio_a[1] zdiv1_ratio_a[0] zdiv1_ratio_p5_a bypassnnnnh clkrefxxh fractionnnnnh[23] fractionnnnnh[22] fractionnnnnh[21] fractionnnnnh[20] fractionnnnnh[19] fractionnnnnh[18] fractionnnnnh[17] fractionnnnnh[16] fractionnnnnh[15] fractionnnnnh[14] fractionnnnnh[13] fractionnnnnh[12] fractionnnnnh[11] fractionnnnnh[10] fractionnnnnh[9] fractionnnnnh[8] fractionnnnnh[7] fractionnnnnh[6] fractionnnnnh[5] fractionnnnnh[4] fractionnnnnh[3] fractionnnnnh[2] fractionnnnnh[1] fractionnnnnh[0] fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] fz_cpnbias[1] fz_cpnbias[0] fz_dca_cb[1] fz_dca_cb[0] fz_dca_ctrl[5] fz_dca_ctrl[4] fz_dca_ctrl[3] fz_dca_ctrl[2] fz_dca_ctrl[1] fz_dca_ctrl[0] fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] fz_ldo_vinvoltsel[1] fz_ldo_vinvoltsel[0] fz_ldo_bypass fz_ldo_extrefsel fz_ldo_faststart fz_ldo_fbtrim[3] fz_ldo_fbtrim[2] fz_ldo_fbtrim[1] fz_ldo_fbtrim[0] fz_ldo_reftrim[3] fz_ldo_reftrim[2] fz_ldo_reftrim[1] fz_ldo_reftrim[0] fz_lockcnt[2] fz_lockcnt[1] fz_lockcnt[0] fz_lockforce fz_lockstickyb fz_lockthresh[3] fz_lockthresh[2] fz_lockthresh[1] fz_lockthresh[0] fz_lpfclksel fz_nopfdpwrgate fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] fz_pfddly[1] fz_pfddly[0] fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] fz_spare[4] fz_spare[3] fz_spare[2] fz_spare[1] fz_spare[0] fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] fz_tight_loopb fz_vcosel fz_vcotrim[10] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] idvdisable_bi idvfreqai idvfreqbi idvpulsei idvtclki idvtctrli idvtdi idvtresi ldo_enable mash_order_plus_one mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] reset_b_nnnnh rationnnnh[9] rationnnnh[8] rationnnnh[7] rationnnnh[6] rationnnnh[5] rationnnnh[4] rationnnnh[3] rationnnnh[2] rationnnnh[1] rationnnnh[0] ssccyctopeakm1[8] ssccyctopeakm1[7] ssccyctopeakm1[6] ssccyctopeakm1[5] ssccyctopeakm1[4] ssccyctopeakm1[3] ssccyctopeakm1[2] ssccyctopeakm1[1] ssccyctopeakm1[0] ssc_en ssc_frac_step[23] ssc_frac_step[22] ssc_frac_step[21] ssc_frac_step[20] ssc_frac_step[19] ssc_frac_step[18] ssc_frac_step[17] ssc_frac_step[16] ssc_frac_step[15] ssc_frac_step[14] ssc_frac_step[13] ssc_frac_step[12] ssc_frac_step[11] ssc_frac_step[10] ssc_frac_step[9] ssc_frac_step[8] ssc_frac_step[7] ssc_frac_step[6] ssc_frac_step[5] ssc_frac_step[4] ssc_frac_step[3] ssc_frac_step[2] ssc_frac_step[1] ssc_frac_step[0] tck tcapturedr tdi treg_en trst_n tshiftdr tupdatedr vdd vcodiv_ratio[1] vcodiv_ratio[0] vssx zdiv0_ratio[9] zdiv0_ratio[8] zdiv0_ratio[7] zdiv0_ratio[6] zdiv0_ratio[5] zdiv0_ratio[4] zdiv0_ratio[3] zdiv0_ratio[2] zdiv0_ratio[1] zdiv0_ratio[0] zdiv0_ratio_p5 zdiv1_ratio[9] zdiv1_ratio[8] zdiv1_ratio[7] zdiv1_ratio[6] zdiv1_ratio[5] zdiv1_ratio[4] zdiv1_ratio[3] zdiv1_ratio[2] zdiv1_ratio[1] zdiv1_ratio[0] zdiv1_ratio_p5 ta_ldo_hiz_debug ta_ldo_idq_debug dfx_viewselnnnnh0[4] dfx_viewselnnnnh0[3] dfx_viewselnnnnh0[2] dfx_viewselnnnnh0[1] dfx_viewselnnnnh0[0] ta_spare[4] ta_spare[3] ta_spare[2] ta_spare[1] ta_spare[0] plldistpwrgoodnnnnh view_adc_dig_out[9] view_adc_dig_out[8] view_adc_dig_out[7] view_adc_dig_out[6] view_adc_dig_out[5] view_adc_dig_out[4] view_adc_dig_out[3] view_adc_dig_out[2] view_adc_dig_out[1] view_adc_dig_out[0] view_adc_done dfx_viewselnnnnh1[4] dfx_viewselnnnnh1[3] dfx_viewselnnnnh1[2] dfx_viewselnnnnh1[1] dfx_viewselnnnnh1[0] dfx_viewdigennnnnh[1] dfx_viewdigennnnnh[0] dfx_viewanaennnnnh[1] dfx_viewanaennnnnh[0] earlylockxxnnnh lockxxnnnl clkidvih lock_detector_rawlockxxnnnl adc_ctl_startxxh adc_ctl_reset_bxxl dfx_adc_clkdiv[1] dfx_adc_clkdiv[0] dfx_adc_freeze dfx_adc_chop_en dfx_adc_use_vref dfx_adc_sel_in[2] dfx_adc_sel_in[1] dfx_adc_sel_in[0] pll_fbgen_clkfbmxh pll_core_pfdlockrstnnnnh reset_sync_bypassenxxnnnl dfx_powergood view_mux_viewoutnnnnh[1] view_mux_viewoutnnnnh[0] ssc_directionmxh idv_fub_idvgateennh idv_rdacctlth[3] idv_rdacctlth[2] idv_rdacctlth[1] idv_rdacctlth[0] ssc_mod_dfx_clkmodmxh startup_gen_pfdenxxh startup_gen_vctlrdacenxxh tlctrl_sip_tightloopxxnnnh vctl_trim_fsm_vctlrdacshortxxh global_align_gateclkdistxxnnnl idfx_fscan_sdi[2] idfx_fscan_sdi[1] idfx_fscan_sdi[0] odfx_fscan_sdo[2] odfx_fscan_sdo[1] odfx_fscan_sdo[0] idfx_fscan_clkungate idfx_fscan_byprstb idfx_fscan_rstbypen idfx_fscan_shiften idfx_fscan_mode
* .PININFO bypassnnnnh:I clkidvih:I clkrefxxh:I fractionnnnnh[23]:I fractionnnnnh[22]:I fractionnnnnh[21]:I fractionnnnnh[20]:I fractionnnnnh[19]:I
* .PININFO fractionnnnnh[18]:I fractionnnnnh[17]:I fractionnnnnh[16]:I fractionnnnnh[15]:I fractionnnnnh[14]:I fractionnnnnh[13]:I fractionnnnnh[12]:I
* .PININFO fractionnnnnh[11]:I fractionnnnnh[10]:I fractionnnnnh[9]:I fractionnnnnh[8]:I fractionnnnnh[7]:I fractionnnnnh[6]:I fractionnnnnh[5]:I
* .PININFO fractionnnnnh[4]:I fractionnnnnh[3]:I fractionnnnnh[2]:I fractionnnnnh[1]:I fractionnnnnh[0]:I fz_cp1trim[4]:I fz_cp1trim[3]:I
* .PININFO fz_cp1trim[2]:I fz_cp1trim[1]:I fz_cp1trim[0]:I fz_cp2trim[4]:I fz_cp2trim[3]:I fz_cp2trim[2]:I fz_cp2trim[1]:I fz_cp2trim[0]:I
* .PININFO fz_cpnbias[1]:I fz_cpnbias[0]:I fz_dca_cb[1]:I fz_dca_cb[0]:I fz_dca_ctrl[5]:I fz_dca_ctrl[4]:I fz_dca_ctrl[3]:I fz_dca_ctrl[2]:I
* .PININFO fz_dca_ctrl[1]:I fz_dca_ctrl[0]:I fz_irefgen[4]:I fz_irefgen[3]:I fz_irefgen[2]:I fz_irefgen[1]:I fz_irefgen[0]:I fz_ldo_bypass:I
* .PININFO fz_ldo_extrefsel:I fz_ldo_faststart:I fz_ldo_fbtrim[3]:I fz_ldo_fbtrim[2]:I fz_ldo_fbtrim[1]:I fz_ldo_fbtrim[0]:I fz_ldo_reftrim[3]:I
* .PININFO fz_ldo_reftrim[2]:I fz_ldo_reftrim[1]:I fz_ldo_reftrim[0]:I fz_ldo_vinvoltsel[1]:I fz_ldo_vinvoltsel[0]:I fz_lockcnt[2]:I fz_lockcnt[1]:I
* .PININFO fz_lockcnt[0]:I fz_lockforce:I fz_lockstickyb:I fz_lockthresh[3]:I fz_lockthresh[2]:I fz_lockthresh[1]:I fz_lockthresh[0]:I fz_lpfclksel:I
* .PININFO fz_nopfdpwrgate:I fz_pfd_pw[2]:I fz_pfd_pw[1]:I fz_pfd_pw[0]:I fz_pfddly[1]:I fz_pfddly[0]:I fz_skadj[4]:I fz_skadj[3]:I fz_skadj[2]:I
* .PININFO fz_skadj[1]:I fz_skadj[0]:I fz_spare[4]:I fz_spare[3]:I fz_spare[2]:I fz_spare[1]:I fz_spare[0]:I fz_startup[5]:I fz_startup[4]:I
* .PININFO fz_startup[3]:I fz_startup[2]:I fz_startup[1]:I fz_startup[0]:I fz_tight_loopb:I fz_vcosel:I fz_vcotrim[10]:I fz_vcotrim[9]:I
* .PININFO fz_vcotrim[8]:I fz_vcotrim[7]:I fz_vcotrim[6]:I fz_vcotrim[5]:I fz_vcotrim[4]:I fz_vcotrim[3]:I fz_vcotrim[2]:I fz_vcotrim[1]:I
* .PININFO fz_vcotrim[0]:I idfx_fscan_byprstb:I idfx_fscan_clkungate:I idfx_fscan_mode:I idfx_fscan_rstbypen:I idfx_fscan_sdi[2]:I idfx_fscan_sdi[1]:I
* .PININFO idfx_fscan_sdi[0]:I idfx_fscan_shiften:I idvdisable_bi:I idvfreqai:I idvfreqbi:I idvpulsei:I idvtclki:I idvtctrli:I idvtdi:I idvtresi:I
* .PININFO ldo_enable:I mash_order_plus_one:I mdiv_ratio[5]:I mdiv_ratio[4]:I mdiv_ratio[3]:I mdiv_ratio[2]:I mdiv_ratio[1]:I mdiv_ratio[0]:I
* .PININFO pll_core_pfdlockrstnnnnh:I pll_fbgen_clkfbmxh:I plldistpwrgoodnnnnh:I rationnnnh[9]:I rationnnnh[8]:I rationnnnh[7]:I rationnnnh[6]:I
* .PININFO rationnnnh[5]:I rationnnnh[4]:I rationnnnh[3]:I rationnnnh[2]:I rationnnnh[1]:I rationnnnh[0]:I reset_b_nnnnh:I ssc_en:I
* .PININFO ssc_frac_step[23]:I ssc_frac_step[22]:I ssc_frac_step[21]:I ssc_frac_step[20]:I ssc_frac_step[19]:I ssc_frac_step[18]:I ssc_frac_step[17]:I
* .PININFO ssc_frac_step[16]:I ssc_frac_step[15]:I ssc_frac_step[14]:I ssc_frac_step[13]:I ssc_frac_step[12]:I ssc_frac_step[11]:I ssc_frac_step[10]:I
* .PININFO ssc_frac_step[9]:I ssc_frac_step[8]:I ssc_frac_step[7]:I ssc_frac_step[6]:I ssc_frac_step[5]:I ssc_frac_step[4]:I ssc_frac_step[3]:I
* .PININFO ssc_frac_step[2]:I ssc_frac_step[1]:I ssc_frac_step[0]:I ssccyctopeakm1[8]:I ssccyctopeakm1[7]:I ssccyctopeakm1[6]:I ssccyctopeakm1[5]:I
* .PININFO ssccyctopeakm1[4]:I ssccyctopeakm1[3]:I ssccyctopeakm1[2]:I ssccyctopeakm1[1]:I ssccyctopeakm1[0]:I tcapturedr:I tck:I tdi:I treg_en:I
* .PININFO trst_n:I tshiftdr:I tupdatedr:I vcodiv_ratio[1]:I vcodiv_ratio[0]:I vdd:I view_adc_dig_out[9]:I view_adc_dig_out[8]:I view_adc_dig_out[7]:I
* .PININFO view_adc_dig_out[6]:I view_adc_dig_out[5]:I view_adc_dig_out[4]:I view_adc_dig_out[3]:I view_adc_dig_out[2]:I view_adc_dig_out[1]:I
* .PININFO view_adc_dig_out[0]:I view_adc_done:I view_mux_viewoutnnnnh[1]:I view_mux_viewoutnnnnh[0]:I vssx:I zdiv0_ratio[9]:I zdiv0_ratio[8]:I
* .PININFO zdiv0_ratio[7]:I zdiv0_ratio[6]:I zdiv0_ratio[5]:I zdiv0_ratio[4]:I zdiv0_ratio[3]:I zdiv0_ratio[2]:I zdiv0_ratio[1]:I zdiv0_ratio[0]:I
* .PININFO zdiv0_ratio_p5:I zdiv1_ratio[9]:I zdiv1_ratio[8]:I zdiv1_ratio[7]:I zdiv1_ratio[6]:I zdiv1_ratio[5]:I zdiv1_ratio[4]:I zdiv1_ratio[3]:I
* .PININFO zdiv1_ratio[2]:I zdiv1_ratio[1]:I zdiv1_ratio[0]:I zdiv1_ratio_p5:I adc_ctl_reset_bxxl:O adc_ctl_startxxh:O dfx_adc_chop_en:O
* .PININFO dfx_adc_clkdiv[1]:O dfx_adc_clkdiv[0]:O dfx_adc_freeze:O dfx_adc_sel_in[2]:O dfx_adc_sel_in[1]:O dfx_adc_sel_in[0]:O dfx_adc_use_vref:O
* .PININFO dfx_cp1_trim[4]:O dfx_cp1_trim[3]:O dfx_cp1_trim[2]:O dfx_cp1_trim[1]:O dfx_cp1_trim[0]:O dfx_cp2_trim[4]:O dfx_cp2_trim[3]:O
* .PININFO dfx_cp2_trim[2]:O dfx_cp2_trim[1]:O dfx_cp2_trim[0]:O dfx_dca_ctrl[5]:O dfx_dca_ctrl[4]:O dfx_dca_ctrl[3]:O dfx_dca_ctrl[2]:O
* .PININFO dfx_dca_ctrl[1]:O dfx_dca_ctrl[0]:O dfx_lockthresh[3]:O dfx_lockthresh[2]:O dfx_lockthresh[1]:O dfx_lockthresh[0]:O dfx_powergood:O
* .PININFO dfx_skadj_ctrl[4]:O dfx_skadj_ctrl[3]:O dfx_skadj_ctrl[2]:O dfx_skadj_ctrl[1]:O dfx_skadj_ctrl[0]:O dfx_tight_loop:O
* .PININFO dfx_viewanaennnnnh[1]:O dfx_viewanaennnnnh[0]:O dfx_viewdigennnnnh[1]:O dfx_viewdigennnnnh[0]:O dfx_viewselnnnnh0[4]:O
* .PININFO dfx_viewselnnnnh0[3]:O dfx_viewselnnnnh0[2]:O dfx_viewselnnnnh0[1]:O dfx_viewselnnnnh0[0]:O dfx_viewselnnnnh1[4]:O dfx_viewselnnnnh1[3]:O
* .PININFO dfx_viewselnnnnh1[2]:O dfx_viewselnnnnh1[1]:O dfx_viewselnnnnh1[0]:O earlylockxxnnnh:O fz_cpnbias_a[1]:O fz_cpnbias_a[0]:O fz_dca_cb_a[1]:O
* .PININFO fz_dca_cb_a[0]:O fz_irefgen_a[4]:O fz_irefgen_a[3]:O fz_irefgen_a[2]:O fz_irefgen_a[1]:O fz_irefgen_a[0]:O fz_ldo_bypass_a:O
* .PININFO fz_ldo_extrefsel_a:O fz_ldo_faststart_a:O fz_ldo_fbtrim_a[3]:O fz_ldo_fbtrim_a[2]:O fz_ldo_fbtrim_a[1]:O fz_ldo_fbtrim_a[0]:O
* .PININFO fz_ldo_reftrim_a[3]:O fz_ldo_reftrim_a[2]:O fz_ldo_reftrim_a[1]:O fz_ldo_reftrim_a[0]:O fz_ldo_vinvoltsel_a[1]:O fz_ldo_vinvoltsel_a[0]:O
* .PININFO fz_lpfclksel_a:O fz_nopfdpwrgate_a:O fz_pfd_pw_a[2]:O fz_pfd_pw_a[1]:O fz_pfd_pw_a[0]:O fz_pfddly_a[1]:O fz_pfddly_a[0]:O fz_spare_a[4]:O
* .PININFO fz_spare_a[3]:O fz_spare_a[2]:O fz_spare_a[1]:O fz_spare_a[0]:O fz_startup_a[5]:O fz_startup_a[4]:O fz_startup_a[3]:O fz_startup_a[2]:O
* .PININFO fz_startup_a[1]:O fz_startup_a[0]:O fz_vcosel_a:O fz_vcotrim_a[10]:O fz_vcotrim_a[9]:O fz_vcotrim_a[8]:O fz_vcotrim_a[7]:O
* .PININFO fz_vcotrim_a[6]:O fz_vcotrim_a[5]:O fz_vcotrim_a[4]:O fz_vcotrim_a[3]:O fz_vcotrim_a[2]:O fz_vcotrim_a[1]:O fz_vcotrim_a[0]:O
* .PININFO global_align_gateclkdistxxnnnl:O idv_fub_idvgateennh:O idv_rdacctlth[3]:O idv_rdacctlth[2]:O idv_rdacctlth[1]:O idv_rdacctlth[0]:O
* .PININFO idvdisable_bo:O idvfreqao:O idvfreqbo:O idvpulseo:O idvtclko:O idvtctrlo:O idvtdo:O idvtreso:O ldo_enable_a:O lock_detector_rawlockxxnnnl:O
* .PININFO lockxxnnnl:O mash_halfintmxh:O mash_ratiomxh[9]:O mash_ratiomxh[8]:O mash_ratiomxh[7]:O mash_ratiomxh[6]:O mash_ratiomxh[5]:O
* .PININFO mash_ratiomxh[4]:O mash_ratiomxh[3]:O mash_ratiomxh[2]:O mash_ratiomxh[1]:O mash_ratiomxh[0]:O mdiv_ratio_a[5]:O mdiv_ratio_a[4]:O
* .PININFO mdiv_ratio_a[3]:O mdiv_ratio_a[2]:O mdiv_ratio_a[1]:O mdiv_ratio_a[0]:O odfx_fscan_sdo[2]:O odfx_fscan_sdo[1]:O odfx_fscan_sdo[0]:O
* .PININFO reset_sync_bypassenxxnnnl:O reset_sync_bypassxxnnnl:O reset_sync_reset_b_xxnnnl:O ssc_directionmxh:O ssc_mod_dfx_clkmodmxh:O
* .PININFO startup_gen_pfdenxxh:O startup_gen_vctlrdacenxxh:O ta_ldo_hiz_debug:O ta_ldo_idq_debug:O ta_spare[4]:O ta_spare[3]:O ta_spare[2]:O
* .PININFO ta_spare[1]:O ta_spare[0]:O tdo:O tlctrl_sip_tightloopxxnnnh:O vcodiv_ratio_a[1]:O vcodiv_ratio_a[0]:O vctl_trim_fsm_vctlrdacshortxxh:O
* .PININFO zdiv0_ratio_a[9]:O zdiv0_ratio_a[8]:O zdiv0_ratio_a[7]:O zdiv0_ratio_a[6]:O zdiv0_ratio_a[5]:O zdiv0_ratio_a[4]:O zdiv0_ratio_a[3]:O
* .PININFO zdiv0_ratio_a[2]:O zdiv0_ratio_a[1]:O zdiv0_ratio_a[0]:O zdiv0_ratio_p5_a:O zdiv1_ratio_a[9]:O zdiv1_ratio_a[8]:O zdiv1_ratio_a[7]:O
* .PININFO zdiv1_ratio_a[6]:O zdiv1_ratio_a[5]:O zdiv1_ratio_a[4]:O zdiv1_ratio_a[3]:O zdiv1_ratio_a[2]:O zdiv1_ratio_a[1]:O zdiv1_ratio_a[0]:O
* .PININFO zdiv1_ratio_p5_a:O
Xsip ctsbuf_net_16549 reset_b_nnnnh plldistpwrgoodnnnnh bypassnnnnh rationnnnh[9] rationnnnh[8] rationnnnh[7] rationnnnh[6] rationnnnh[5] rationnnnh[4] rationnnnh[3] rationnnnh[2] rationnnnh[1] rationnnnh[0] fractionnnnnh[23] fractionnnnnh[22] fractionnnnnh[21] fractionnnnnh[20] fractionnnnnh[19] fractionnnnnh[18] fractionnnnnh[17] fractionnnnnh[16] fractionnnnnh[15] fractionnnnnh[14] fractionnnnnh[13] fractionnnnnh[12] fractionnnnnh[11] fractionnnnnh[10] fractionnnnnh[9] fractionnnnnh[8] fractionnnnnh[7] fractionnnnnh[6] fractionnnnnh[5] fractionnnnnh[4] fractionnnnnh[3] fractionnnnnh[2] fractionnnnnh[1] fractionnnnnh[0] pll_fbgen_clkfbmxh pll_core_pfdlockrstnnnnh view_adc_dig_out[9] view_adc_dig_out[8] view_adc_dig_out[7] view_adc_dig_out[6] view_adc_dig_out[5] view_adc_dig_out[4] view_adc_dig_out[3] view_adc_dig_out[2] view_adc_dig_out[1] view_adc_dig_out[0] view_adc_done reset_sync__bypassxxnnnl_int reset_sync_reset_b_xxnnnl reset_sync_bypassenxxnnnl dfx_powergood dfx_reset_b_pre dfx_viewdigennnnnh[1] dfx_viewdigennnnnh[0] dfx_viewanaennnnnh[1] dfx_viewanaennnnnh[0] dfx_viewselnnnnh1[4] dfx_viewselnnnnh1[3] dfx_viewselnnnnh1[2] dfx_viewselnnnnh1[1] dfx_viewselnnnnh1[0] dfx_viewselnnnnh0[4] dfx_viewselnnnnh0[3] dfx_viewselnnnnh0[2] dfx_viewselnnnnh0[1] dfx_viewselnnnnh0[0] dmfix_synopsys_unconnected_1 ctsbuf_net_27560 ssc_directionmxh mash_ratiomxh[9] mash_ratiomxh[8] mash_ratiomxh[7] mash_ratiomxh[6] mash_ratiomxh[5] mash_ratiomxh[4] mash_ratiomxh[3] mash_ratiomxh[2] mash_ratiomxh[1] mash_ratiomxh[0] mash_halfintmxh idv_fub_idvgateennh idv_rdacctlth[3] idv_rdacctlth[2] idv_rdacctlth[1] idv_rdacctlth[0] fz_vcotrim_a[9] fz_vcotrim_a[8] fz_vcotrim_a[7] fz_vcotrim_a[6] fz_vcotrim_a[2] fz_vcotrim_a[1] fz_vcotrim_a[0] startup_gen_vctlrdacenxxh startup_gen_pfdenxxh vctl_trim_fsm_vctlrdacshortxxh earlylockxxnnnh lock_int tap_in[202] tap_in[201] tap_in[200] tap_in[199] tap_in[198] tap_in[197] buf_net_567 tap_in[195] tap_in[194] tap_in[193] tap_in[192] tap_in[191] tap_in[190] tap_in[189] tap_in[188] tap_in[187] tap_in[186] tap_in[185] tap_in[184] tap_in[183] tap_in[182] tap_in[181] tap_in[180] tap_in[179] tap_in[178] tap_in[177] tap_in[176] tap_in[175] tap_in[174] tap_in[173] tap_in[172] tap_in[171] tap_in[170] tap_in[169] tap_in[168] tap_in[167] tap_in[166] tap_in[165] tap_in[164] tap_in[163] tap_in[162] tap_in[161] tap_in[160] tap_in[159] tap_in[158] tap_in[157] tap_in[156] tap_in[155] tap_in[154] tap_in[153] tap_in[152] tap_in[151] tap_in[150] tap_in[149] tap_in[148] tap_in[147] tap_in[146] tap_in[145] tap_in[144] tap_in[143] tap_in[142] tap_in[141] tap_in[140] tap_in[139] tap_in[138] tap_in[137] tap_in[136] tap_in[135] tap_in[134] tap_in[133] tap_in[132] tap_in[131] tap_in[130] tap_in[129] tap_in[128] tap_in[127] tap_in[126] dmfix_synopsys_unconnected_2 dmfix_synopsys_unconnected_3 dmfix_synopsys_unconnected_4 tap_in[125] tap_in[124] tap_in[123] tap_in[122] tap_in[121] tap_in[120] tap_in[119] tap_in[118] tap_in[117] tap_in[116] tap_in[115] tap_in[114] tap_in[113] tap_in[112] tap_in[111] tap_in[110] tap_in[109] tap_in[108] tap_in[107] tap_in[106] tap_in[105] tap_in[104] dmfix_synopsys_unconnected_5 tap_in[103] tap_in[102] tap_in[101] tap_in[100] tap_in[99] tap_in[98] tap_in[97] tap_in[96] tap_in[95] tap_in[94] tap_in[93] tap_in[92] tap_in[91] tap_in[90] tap_in[89] tap_in[88] tap_in[87] tap_in[86] tap_in[85] tap_in[84] tap_in[83] tap_in[82] tap_in[81] tap_in[80] tap_in[79] tap_in[78] tap_in[77] tap_in[76] tap_in[75] tap_in[74] tap_in[73] tap_in[72] tap_in[71] tap_in[70] tap_in[69] tap_in[68] tap_in[67] tap_in[66] tap_in[65] tap_in[64] tap_in[63] tap_in[62] tap_in[61] tap_in[60] tap_in[59] tap_in[58] tap_in[57] tap_in[56] tap_in[55] tap_in[54] tap_in[53] tap_in[52] tap_in[51] tap_in[50] tap_in[49] tap_in[48] tap_in[47] tap_in[46] tap_in[45] tap_in[44] tap_in[43] tap_in[42] tap_in[41] tap_in[40] tap_in[39] tap_in[38] tap_in[37] tap_in[36] tap_in[35] tap_in[34] tap_in[33] tap_in[32] tap_in[31] tap_in[30] tap_in[29] tap_in[28] tap_in[27] tap_in[26] tap_in[25] tap_in[24] tap_in[23] tap_in[22] tap_in[21] tap_in[20] tap_in[19] tap_in[18] tap_in[17] tap_in[16] tap_in[15] tap_in[14] tap_in[13] tap_in[12] tap_in[11] tap_in[10] tap_in[9] tap_in[8] tap_in[7] tap_in[6] tap_in[5] tap_in[4] tap_in[3] tap_in[2] tap_in[1] tap_in[0] tap_out[60] tap_out[59] dmfix_synopsys_unconnected_6 tap_out[58] tap_out[57] tap_out[56] tap_out[55] tap_out[54] tap_out[53] tap_out[52] tap_out[51] tap_out[50] tap_out[49] tap_out[48] tap_out[47] tap_out[46] tap_out[45] tap_out[44] tap_out[43] tap_out[42] tap_out[41] tap_out[40] tap_out[39] tap_out[38] tap_out[37] tap_out[36] tap_out[35] tap_out[34] tap_out[33] tap_out[32] tap_out[31] tap_out[30] tap_out[29] tap_out[28] tap_out[27] tap_out[26] tap_out[25] tap_out[24] tap_out[23] tap_out[22] tap_out[21] tap_out[20] tap_out[19] tap_out[18] tap_out[17] tap_out[16] tap_out[15] tap_out[14] tap_out[13] tap_out[12] tap_out[11] tap_out[10] tap_out[9] tap_out[8] tap_out[7] tap_out[6] tap_out[5] tap_out[4] tap_out[3] tap_out[2] tap_out[1] tap_out[0] clkidvih lock_detector_rawlockxxnnnl cts0 adc_ctl_startxxh adc_ctl_reset_bxxl dfx_adc_clkdiv[1] dfx_adc_clkdiv[0] dfx_adc_freeze dfx_adc_chop_en dfx_adc_use_vref dfx_adc_sel_in[2] dfx_adc_sel_in[1] dfx_adc_sel_in[0] dfx_tight_loop dfx_cp1_trim[4] dfx_cp1_trim[3] dfx_cp1_trim[2] dfx_cp1_trim[1] dfx_cp1_trim[0] dfx_cp2_trim[4] dfx_cp2_trim[3] dfx_cp2_trim[2] dfx_cp2_trim[1] dfx_cp2_trim[0] dfx_skadj_ctrl[4] dfx_skadj_ctrl[3] dfx_skadj_ctrl[2] dfx_skadj_ctrl[1] dfx_skadj_ctrl[0] dfx_lockthresh[3] dfx_lockthresh[2] dfx_lockthresh[1] dfx_lockthresh[0] dfx_dca_ctrl[5] dfx_dca_ctrl[4] dfx_dca_ctrl[3] dfx_dca_ctrl[2] dfx_dca_ctrl[1] dfx_dca_ctrl[0] fz_dca_cb_a[1] fz_dca_cb_a[0] tlctrl_sip_tightloopxxnnnh fz_tight_loopb fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] fz_dca_cb[1] fz_dca_cb[0] fz_dca_ctrl[5] fz_dca_ctrl[4] fz_dca_ctrl[3] fz_dca_ctrl[2] fz_dca_ctrl[1] fz_dca_ctrl[0] fz_lockcnt[2] fz_lockcnt[1] fz_lockcnt[0] fz_lockforce dmfix_synopsys_unconnected_7 fz_lockthresh[3] fz_lockthresh[2] fz_lockthresh[1] fz_lockthresh[0] fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] fz_cpnbias[1] fz_cpnbias[0] fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] fz_nopfdpwrgate fz_lpfclksel fz_pfddly[1] fz_pfddly[0] fz_spare[4] fz_spare[3] fz_spare[2] fz_spare[1] fz_spare[0] fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] fz_vcosel fz_vcotrim[10] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] fz_ldo_vinvoltsel[1] fz_ldo_vinvoltsel[0] fz_ldo_bypass fz_ldo_extrefsel fz_ldo_faststart fz_ldo_fbtrim[3] fz_ldo_fbtrim[2] fz_ldo_fbtrim[1] fz_ldo_fbtrim[0] fz_ldo_reftrim[3] fz_ldo_reftrim[2] fz_ldo_reftrim[1] fz_ldo_reftrim[0] fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] mash_order_plus_one ssccyctopeakm1[8] ssccyctopeakm1[7] ssccyctopeakm1[6] ssccyctopeakm1[5] ssccyctopeakm1[4] ssccyctopeakm1[3] ssccyctopeakm1[2] ssccyctopeakm1[1] ssccyctopeakm1[0] ssc_en ssc_frac_step[23] ssc_frac_step[22] ssc_frac_step[21] ssc_frac_step[20] ssc_frac_step[19] ssc_frac_step[18] ssc_frac_step[17] ssc_frac_step[16] ssc_frac_step[15] ssc_frac_step[14] ssc_frac_step[13] ssc_frac_step[12] ssc_frac_step[11] ssc_frac_step[10] ssc_frac_step[9] ssc_frac_step[8] ssc_frac_step[7] ssc_frac_step[6] ssc_frac_step[5] ssc_frac_step[4] ssc_frac_step[3] ssc_frac_step[2] ssc_frac_step[1] ssc_frac_step[0] ldo_enable mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] vcodiv_ratio[1] vcodiv_ratio[0] zdiv0_ratio[9] zdiv0_ratio[8] zdiv0_ratio[7] zdiv0_ratio[6] zdiv0_ratio[5] zdiv0_ratio[4] zdiv0_ratio[3] zdiv0_ratio[2] zdiv0_ratio[1] zdiv0_ratio[0] zdiv0_ratio_p5 zdiv1_ratio[9] zdiv1_ratio[8] zdiv1_ratio[7] zdiv1_ratio[6] zdiv1_ratio[5] zdiv1_ratio[4] zdiv1_ratio[3] zdiv1_ratio[2] zdiv1_ratio[1] zdiv1_ratio[0] zdiv1_ratio_p5 idvdisable_bi idvfreqai idvfreqbi idvpulsei ctsbuf_net_9542 idvtctrli idvtdi idvtresi idvdisable_bo idvfreqao idvfreqbo idvpulseo optlc_net_561 idvtctrlo idvtdo idvtreso ldo_enable_a ta_ldo_hiz_debug ta_ldo_idq_debug ta_spare[4] ta_spare[3] ta_spare[2] ta_spare[1] ta_spare[0] fz_ldo_vinvoltsel_a[1] fz_ldo_vinvoltsel_a[0] fz_ldo_bypass_a fz_ldo_extrefsel_a fz_ldo_faststart_a fz_ldo_fbtrim_a[3] fz_ldo_fbtrim_a[2] fz_ldo_fbtrim_a[1] fz_ldo_fbtrim_a[0] fz_ldo_reftrim_a[3] fz_ldo_reftrim_a[2] fz_ldo_reftrim_a[1] fz_ldo_reftrim_a[0] mdiv_ratio_a[5] mdiv_ratio_a[4] mdiv_ratio_a[3] mdiv_ratio_a[2] mdiv_ratio_a[1] mdiv_ratio_a[0] vcodiv_ratio_a[1] vcodiv_ratio_a[0] zdiv0_ratio_a[9] zdiv0_ratio_a[8] zdiv0_ratio_a[7] zdiv0_ratio_a[6] zdiv0_ratio_a[5] zdiv0_ratio_a[4] zdiv0_ratio_a[3] zdiv0_ratio_a[2] zdiv0_ratio_a[1] zdiv0_ratio_a[0] zdiv0_ratio_p5_a zdiv1_ratio_a[9] zdiv1_ratio_a[8] zdiv1_ratio_a[7] zdiv1_ratio_a[6] zdiv1_ratio_a[5] zdiv1_ratio_a[4] zdiv1_ratio_a[3] zdiv1_ratio_a[2] zdiv1_ratio_a[1] zdiv1_ratio_a[0] zdiv1_ratio_p5_a fz_cpnbias_a[1] fz_cpnbias_a[0] fz_irefgen_a[4] fz_irefgen_a[3] fz_irefgen_a[2] fz_irefgen_a[1] fz_irefgen_a[0] fz_lpfclksel_a fz_nopfdpwrgate_a fz_pfd_pw_a[2] fz_pfd_pw_a[1] fz_pfd_pw_a[0] fz_pfddly_a[1] fz_pfddly_a[0] fz_spare_a[4] fz_spare_a[3] fz_spare_a[2] fz_spare_a[1] fz_spare_a[0] fz_startup_a[5] fz_startup_a[4] fz_startup_a[3] fz_startup_a[2] fz_startup_a[1] fz_startup_a[0] fz_vcosel_a fz_vcotrim_a[10] dmfix_synopsys_unconnected_8 dmfix_synopsys_unconnected_9 dmfix_synopsys_unconnected_10 dmfix_synopsys_unconnected_11 fz_vcotrim_a[5] fz_vcotrim_a[4] fz_vcotrim_a[3] dmfix_synopsys_unconnected_12 dmfix_synopsys_unconnected_13 dmfix_synopsys_unconnected_14 dmfix_synopsys_unconnected_15 idfx_fscan_sdi[2] idfx_fscan_sdi[1] dmfix_synopsys_unconnected_16 dmfix_synopsys_unconnected_17 dmfix_synopsys_unconnected_18 idfx_fscan_rstbypen idfx_fscan_byprstb idfx_fscan_clkungate dmfix_synopsys_unconnected_19 dmfix_synopsys_unconnected_20 dmfix_synopsys_unconnected_21 lock_int4 n13 n15 n18 buft_net_136 vdd vssx p_abuf15 p_abuf16 buft_net_137 buft_net_138 buft_net_140 buft_net_137 buft_net_144 buft_net_141 buft_net_142 buft_net_142 buft_net_139 buft_net_143 p_abuf0 p_abuf1 p_abuf2 p_abuf3 p_abuf4 p_abuf5 p_abuf6 tap_in[128] p_abuf13 p_abuf14 p_abuf9 p_abuf7 p_abuf12 p_abuf10 p_abuf8 p_abuf17 optlc_net_309 optlc_net_310 optlc_net_311 optlc_net_312 optlc_net_313 optlc_net_314 optlc_net_315 optlc_net_317 optlc_net_328 idvtclki optlc_net_357 optlc_net_358 optlc_net_363 optlc_net_364 optlc_net_370 optlc_net_372 p_abuf11 optlc_net_532 cts2 optlc_net_562 clkrefxxh optlc_net_563 view_mux_viewoutnnnnh[0] optlc_net_564 optlc_net_565 optlc_net_566 ringpll__ljpll_sip
Xu7 reset_sync__bypassxxnnnl_int n3 vdd vssx ringpll__b15inv040al1n02x5 m=1
Xu19 optlc_net_332 global_align_gateclkdistxxnnnl vdd vssx ringpll__b15inv040al1n02x5 m=1
Xplace_optlc_450 optlc_net_380 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_448 optlc_net_379 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_446 optlc_net_378 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_444 optlc_net_377 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_442 optlc_net_376 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_440 optlc_net_375 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_438 optlc_net_374 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_436 optlc_net_373 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_432 optlc_net_371 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_429 optlc_net_369 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_427 optlc_net_368 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_425 optlc_net_367 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_423 optlc_net_366 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_421 optlc_net_365 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_415 optlc_net_362 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_413 optlc_net_361 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_411 optlc_net_360 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_409 optlc_net_359 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_403 optlc_net_356 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_402 optlc_net_355 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_400 optlc_net_354 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_398 optlc_net_353 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_396 optlc_net_352 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_394 optlc_net_351 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_392 optlc_net_350 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_390 optlc_net_349 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_388 optlc_net_348 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_386 optlc_net_347 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_384 optlc_net_346 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_382 optlc_net_345 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_380 optlc_net_344 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_378 optlc_net_343 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_376 optlc_net_342 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_374 optlc_net_341 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_372 optlc_net_340 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_370 optlc_net_339 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_368 optlc_net_338 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_366 optlc_net_337 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_364 optlc_net_336 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_362 optlc_net_335 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_360 optlc_net_334 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_358 optlc_net_333 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_355 optlc_net_331 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_351 optlc_net_329 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_347 optlc_net_327 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_343 optlc_net_325 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_341 optlc_net_324 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_339 optlc_net_323 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_337 optlc_net_322 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_335 optlc_net_321 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_333 optlc_net_320 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_331 optlc_net_319 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_329 optlc_net_318 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_434 optlc_net_372 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_431 optlc_net_370 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_419 optlc_net_364 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_417 optlc_net_363 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_407 optlc_net_358 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_405 optlc_net_357 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_349 optlc_net_328 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xpost_cts_optoptlc_2322 optlc_net_564 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xpost_cts_optoptlc_2321 optlc_net_563 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xpost_cts_optoptlc_2320 optlc_net_562 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xpost_cts_optoptlc_2318 optlc_net_561 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_604 optlc_net_532 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_optlc_356 optlc_net_332 vdd vssx ringpll__b15tihi00an1n03x5 m=1
Xplace_ainv_p_588 trst_n buf_net_518 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_ainv_p_595 trst_n buf_net_525 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_ainv_p_594 trst_n buf_net_524 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_ainv_p_590 trst_n buf_net_520 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xpost_cts_optbinv_r_2328 tap_in[196] buf_net_568 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xpost_cts_optbinv_r_2327 buf_net_568 buf_net_567 vdd vssx ringpll__b15inv040ah1n03x5 m=1
Xplace_optlc_310 optlc_net_308 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xplace_optlc_326 optlc_net_317 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xplace_optlc_322 optlc_net_315 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xplace_optlc_318 optlc_net_313 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xpost_cts_optoptlc_2326 optlc_net_566 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xpost_cts_optoptlc_2325 optlc_net_565 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xplace_optlc_316 optlc_net_312 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xplace_optlc_314 optlc_net_311 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xplace_optlc_313 optlc_net_310 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xplace_optlc_312 optlc_net_309 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xplace_optlc_320 optlc_net_314 vdd vssx ringpll__b15revid0an1nm1x5 m=1
Xplace_ainv_p_585 buf_net_518 buf_net_515 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_583 buf_net_518 buf_net_513 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_573 buf_net_518 buf_net_503 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_554 buf_net_518 buf_net_484 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_540 buf_net_518 buf_net_470 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_534 buf_net_518 buf_net_464 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_582 buf_net_525 buf_net_512 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_581 buf_net_525 buf_net_511 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_576 buf_net_525 buf_net_506 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_564 buf_net_525 buf_net_494 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_558 buf_net_524 buf_net_488 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_557 buf_net_522 buf_net_487 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_555 buf_net_522 buf_net_485 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_541 buf_net_522 buf_net_471 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_539 buf_net_522 buf_net_469 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_553 buf_net_520 buf_net_483 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_550 buf_net_520 buf_net_480 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_binv_r_136 idfx_fscan_shiften buft_net_136 vdd vssx ringpll__b15inv000an1n05x5 m=1
Xplace_ainv_p_587 buf_net_518 buf_net_517 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_586 buf_net_518 buf_net_516 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_584 buf_net_518 buf_net_514 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_566 buf_net_518 buf_net_496 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_549 buf_net_518 buf_net_479 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_577 buf_net_525 buf_net_507 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_575 buf_net_525 buf_net_505 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_571 buf_net_525 buf_net_501 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_569 buf_net_525 buf_net_499 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_562 buf_net_525 buf_net_492 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_580 buf_net_519 buf_net_510 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_579 buf_net_519 buf_net_509 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_563 buf_net_519 buf_net_493 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_561 buf_net_519 buf_net_491 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_535 buf_net_519 buf_net_465 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_578 buf_net_524 buf_net_508 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_574 buf_net_524 buf_net_504 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_565 buf_net_524 buf_net_495 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_560 buf_net_524 buf_net_490 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_567 buf_net_522 buf_net_497 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_556 buf_net_522 buf_net_486 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_552 buf_net_522 buf_net_482 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_543 buf_net_522 buf_net_473 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_544 buf_net_520 buf_net_474 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_548 buf_net_521 buf_net_478 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_547 buf_net_521 buf_net_477 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_546 buf_net_521 buf_net_476 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_542 buf_net_521 buf_net_472 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_538 buf_net_521 buf_net_468 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_537 buf_net_521 buf_net_467 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_536 buf_net_521 buf_net_466 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_589 trst_n buf_net_519 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_592 trst_n buf_net_522 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_ainv_p_591 trst_n buf_net_521 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_142 idfx_fscan_shiften buft_net_142 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_141 idfx_fscan_shiften buft_net_141 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_140 idfx_fscan_shiften buft_net_140 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_139 idfx_fscan_shiften buft_net_139 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_138 idfx_fscan_shiften buft_net_138 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_137 idfx_fscan_shiften buft_net_137 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_143 idfx_fscan_shiften buft_net_143 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xplace_binv_r_144 idfx_fscan_shiften buft_net_144 vdd vssx ringpll__b15inv040an1n03x5 m=1
Xcts_sip_idvtclko_bip698 idvtclki idvtclko vdd vssx ringpll__b15cbf000ah1n04x5 m=1
Xcts_cts_buf_10721830 tck ctsbuf_net_19552 vdd vssx ringpll__b15cbf000ah1n08x5 m=1
Xcts_cts_buf_11011859 view_mux_viewoutnnnnh[0] ctsbuf_net_27560 vdd vssx ringpll__b15cbf000ah1n08x5 m=1
Xcts_sip_ssc_mod_dfx__clkmodmxh_bip697 cts0 ssc_mod_dfx_clkmodmxh vdd vssx ringpll__b15cbf000ah1n08x5 m=1
Xcts_cts_buf_10561805 cts2 ctsbuf_net_16549 vdd vssx ringpll__b15cbf000ah1n08x5 m=1
Xlockxxnnnl_reg ctsbuf_net_16549 lock_int4 lockxxnnnl dfx_reset_b n18 buft_net_136 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_int2_reg ctsbuf_net_16549 lock_int1 lock_int2 dfx_reset_b lock_int1 buft_net_144 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_int3_reg ctsbuf_net_16549 lock_int2 lock_int3 dfx_reset_b lock_int2 buft_net_144 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_int4_reg ctsbuf_net_16549 lock_int3 lock_int4 dfx_reset_b lock_int3 buft_net_144 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xlock_int1_reg ctsbuf_net_16549 lock_int lock_int1 dfx_reset_b idfx_fscan_sdi[0] buft_net_143 vdd vssx ringpll__b15fqy003al1n02x3 m=1
Xu8 n3 lock_int fz_spare[2] dfx_tight_loop reset_sync_bypassxxnnnl vdd vssx ringpll__b15oai013ah1n02x5 m=1
Xu6 idfx_fscan_byprstb dfx_reset_b_pre dfx_reset_b idfx_fscan_rstbypen vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu18 optlc_net_314 lockxxnnnl odfx_fscan_sdo[0] buft_net_136 vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu16 optlc_net_314 n13 odfx_fscan_sdo[2] buft_net_136 vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xu17 optlc_net_314 n15 odfx_fscan_sdo[1] buft_net_136 vdd vssx ringpll__b15cmbn22al1n02x5 m=1
Xcts_cts_buf_9991741 idvtclki ctsbuf_net_9542 vdd vssx ringpll__b15cbf000ah1n02x5 m=1
Xcts_cts_dlydt_1813 clkrefxxh cts2 vdd vssx ringpll__b15cbf000ah1n02x5 m=1
Xljpll_rtdr dmfix_synopsys_unconnected_22 ctsbuf_net_19552 tdi buf_net_501 treg_en tcapturedr tshiftdr tupdatedr tap_out[60] tap_out[59] dmfix_synopsys_unconnected_23 tap_out[58] tap_out[57] tap_out[56] tap_out[55] tap_out[54] tap_out[53] tap_out[52] tap_out[51] tap_out[50] tap_out[49] tap_out[48] tap_out[47] tap_out[46] tap_out[45] tap_out[44] tap_out[43] tap_out[42] tap_out[41] tap_out[40] tap_out[39] tap_out[38] tap_out[37] tap_out[36] tap_out[35] tap_out[34] tap_out[33] tap_out[32] tap_out[31] tap_out[30] tap_out[29] tap_out[28] tap_out[27] tap_out[26] tap_out[25] tap_out[24] tap_out[23] tap_out[22] tap_out[21] tap_out[20] tap_out[19] tap_out[18] tap_out[17] tap_out[16] tap_out[15] tap_out[14] tap_out[13] tap_out[12] tap_out[11] tap_out[10] tap_out[9] tap_out[8] tap_out[7] tap_out[6] tap_out[5] tap_out[4] tap_out[3] tap_out[2] tap_out[1] tap_out[0] tap_in[202] tap_in[201] tap_in[200] tap_in[199] tap_in[198] tap_in[197] tap_in[196] tap_in[195] tap_in[194] tap_in[193] tap_in[192] tap_in[191] tap_in[190] tap_in[189] tap_in[188] tap_in[187] tap_in[186] p_abuf17 tap_in[184] tap_in[183] tap_in[182] tap_in[181] tap_in[180] tap_in[179] tap_in[178] tap_in[177] tap_in[176] tap_in[175] tap_in[174] tap_in[173] tap_in[172] tap_in[171] tap_in[170] tap_in[169] tap_in[168] tap_in[167] tap_in[166] tap_in[165] tap_in[164] tap_in[163] tap_in[162] tap_in[161] tap_in[160] tap_in[159] tap_in[158] tap_in[157] tap_in[156] tap_in[155] tap_in[154] tap_in[153] tap_in[152] tap_in[151] tap_in[150] tap_in[149] tap_in[148] tap_in[147] tap_in[146] tap_in[145] tap_in[144] tap_in[143] tap_in[142] tap_in[141] tap_in[140] tap_in[139] tap_in[138] tap_in[137] tap_in[136] tap_in[135] tap_in[134] tap_in[133] tap_in[132] tap_in[131] tap_in[130] tap_in[129] p_abuf16 tap_in[127] tap_in[126] dmfix_synopsys_unconnected_293 dmfix_synopsys_unconnected_294 dmfix_synopsys_unconnected_295 tap_in[125] tap_in[124] tap_in[123] tap_in[122] tap_in[121] tap_in[120] tap_in[119] tap_in[118] tap_in[117] tap_in[116] tap_in[115] tap_in[114] tap_in[113] tap_in[112] tap_in[111] tap_in[110] tap_in[109] tap_in[108] tap_in[107] tap_in[106] tap_in[105] tap_in[104] dmfix_synopsys_unconnected_296 tap_in[103] tap_in[102] tap_in[101] tap_in[100] tap_in[99] tap_in[98] tap_in[97] tap_in[96] tap_in[95] tap_in[94] tap_in[93] tap_in[92] tap_in[91] tap_in[90] tap_in[89] tap_in[88] tap_in[87] tap_in[86] tap_in[85] tap_in[84] tap_in[83] tap_in[82] tap_in[81] tap_in[80] tap_in[79] tap_in[78] tap_in[77] tap_in[76] tap_in[75] tap_in[74] tap_in[73] tap_in[72] tap_in[71] tap_in[70] tap_in[69] tap_in[68] tap_in[67] tap_in[66] tap_in[65] tap_in[64] tap_in[63] tap_in[62] tap_in[61] tap_in[60] tap_in[59] tap_in[58] tap_in[57] tap_in[56] tap_in[55] tap_in[54] tap_in[53] tap_in[52] tap_in[51] tap_in[50] tap_in[49] tap_in[48] tap_in[47] tap_in[46] tap_in[45] tap_in[44] tap_in[43] tap_in[42] tap_in[41] tap_in[40] tap_in[39] tap_in[38] tap_in[37] tap_in[36] tap_in[35] tap_in[34] tap_in[33] tap_in[32] tap_in[31] tap_in[30] tap_in[29] tap_in[28] tap_in[27] tap_in[26] tap_in[25] tap_in[24] tap_in[23] tap_in[22] tap_in[21] tap_in[20] tap_in[19] tap_in[18] tap_in[17] tap_in[16] tap_in[15] tap_in[14] tap_in[13] tap_in[12] tap_in[11] tap_in[10] tap_in[9] tap_in[8] tap_in[7] tap_in[6] tap_in[5] tap_in[4] tap_in[3] tap_in[2] tap_in[1] tap_in[0] tdo dmfix_synopsys_unconnected_24 dmfix_synopsys_unconnected_25 dmfix_synopsys_unconnected_26 dmfix_synopsys_unconnected_27 dmfix_synopsys_unconnected_28 dmfix_synopsys_unconnected_29 dmfix_synopsys_unconnected_30 dmfix_synopsys_unconnected_31 dmfix_synopsys_unconnected_32 dmfix_synopsys_unconnected_33 dmfix_synopsys_unconnected_34 dmfix_synopsys_unconnected_35 dmfix_synopsys_unconnected_36 dmfix_synopsys_unconnected_37 dmfix_synopsys_unconnected_38 dmfix_synopsys_unconnected_39 dmfix_synopsys_unconnected_40 dmfix_synopsys_unconnected_41 dmfix_synopsys_unconnected_42 dmfix_synopsys_unconnected_43 dmfix_synopsys_unconnected_44 dmfix_synopsys_unconnected_45 dmfix_synopsys_unconnected_46 dmfix_synopsys_unconnected_47 dmfix_synopsys_unconnected_48 dmfix_synopsys_unconnected_49 dmfix_synopsys_unconnected_50 dmfix_synopsys_unconnected_51 dmfix_synopsys_unconnected_52 dmfix_synopsys_unconnected_53 dmfix_synopsys_unconnected_54 dmfix_synopsys_unconnected_55 dmfix_synopsys_unconnected_56 dmfix_synopsys_unconnected_57 dmfix_synopsys_unconnected_58 dmfix_synopsys_unconnected_59 dmfix_synopsys_unconnected_60 dmfix_synopsys_unconnected_61 dmfix_synopsys_unconnected_62 dmfix_synopsys_unconnected_63 dmfix_synopsys_unconnected_64 dmfix_synopsys_unconnected_65 dmfix_synopsys_unconnected_66 dmfix_synopsys_unconnected_67 dmfix_synopsys_unconnected_68 dmfix_synopsys_unconnected_69 dmfix_synopsys_unconnected_70 dmfix_synopsys_unconnected_71 dmfix_synopsys_unconnected_72 dmfix_synopsys_unconnected_73 dmfix_synopsys_unconnected_74 dmfix_synopsys_unconnected_75 dmfix_synopsys_unconnected_76 dmfix_synopsys_unconnected_77 dmfix_synopsys_unconnected_78 dmfix_synopsys_unconnected_79 dmfix_synopsys_unconnected_80 dmfix_synopsys_unconnected_81 dmfix_synopsys_unconnected_82 dmfix_synopsys_unconnected_83 dmfix_synopsys_unconnected_84 dmfix_synopsys_unconnected_85 tap_in[202] tap_in[201] tap_in[200] tap_in[199] tap_in[198] tap_in[197] tap_in[196] tap_in[195] tap_in[194] tap_in[193] tap_in[192] tap_in[191] tap_in[190] tap_in[189] tap_in[188] tap_in[187] tap_in[186] tap_in[185] tap_in[184] tap_in[183] tap_in[182] tap_in[181] tap_in[180] tap_in[179] tap_in[178] tap_in[177] tap_in[176] tap_in[175] tap_in[174] tap_in[173] tap_in[172] tap_in[171] tap_in[170] tap_in[169] tap_in[168] tap_in[167] tap_in[166] tap_in[165] tap_in[164] tap_in[163] tap_in[162] tap_in[161] tap_in[160] tap_in[159] tap_in[158] tap_in[157] tap_in[156] tap_in[155] tap_in[154] tap_in[153] tap_in[152] tap_in[151] tap_in[150] tap_in[149] tap_in[148] tap_in[147] tap_in[146] tap_in[145] tap_in[144] tap_in[143] tap_in[142] tap_in[141] tap_in[140] tap_in[139] tap_in[138] tap_in[137] tap_in[136] tap_in[135] tap_in[134] tap_in[133] tap_in[132] tap_in[131] tap_in[130] tap_in[129] tap_in[128] tap_in[127] tap_in[126] dmfix_synopsys_unconnected_293 dmfix_synopsys_unconnected_294 dmfix_synopsys_unconnected_295 tap_in[125] tap_in[124] tap_in[123] tap_in[122] tap_in[121] tap_in[120] tap_in[119] tap_in[118] tap_in[117] tap_in[116] tap_in[115] tap_in[114] tap_in[113] tap_in[112] tap_in[111] tap_in[110] tap_in[109] tap_in[108] tap_in[107] tap_in[106] tap_in[105] tap_in[104] dmfix_synopsys_unconnected_296 tap_in[103] tap_in[102] tap_in[101] tap_in[100] tap_in[99] tap_in[98] tap_in[97] tap_in[96] tap_in[95] tap_in[94] tap_in[93] tap_in[92] tap_in[91] tap_in[90] tap_in[89] tap_in[88] tap_in[87] tap_in[86] tap_in[85] tap_in[84] tap_in[83] tap_in[82] tap_in[81] tap_in[80] tap_in[79] tap_in[78] tap_in[77] tap_in[76] tap_in[75] tap_in[74] tap_in[73] tap_in[72] tap_in[71] tap_in[70] tap_in[69] tap_in[68] tap_in[67] tap_in[66] tap_in[65] tap_in[64] tap_in[63] tap_in[62] tap_in[61] tap_in[60] tap_in[59] tap_in[58] tap_in[57] tap_in[56] tap_in[55] tap_in[54] tap_in[53] tap_in[52] tap_in[51] tap_in[50] tap_in[49] tap_in[48] tap_in[47] tap_in[46] tap_in[45] tap_in[44] tap_in[43] tap_in[42] tap_in[41] tap_in[40] tap_in[39] tap_in[38] tap_in[37] tap_in[36] tap_in[35] tap_in[34] tap_in[33] tap_in[32] tap_in[31] tap_in[30] tap_in[29] tap_in[28] tap_in[27] tap_in[26] tap_in[25] tap_in[24] tap_in[23] tap_in[22] tap_in[21] tap_in[20] tap_in[19] tap_in[18] tap_in[17] tap_in[16] tap_in[15] tap_in[14] tap_in[13] tap_in[12] tap_in[11] tap_in[10] tap_in[9] tap_in[8] tap_in[7] tap_in[6] tap_in[5] tap_in[4] tap_in[3] tap_in[2] tap_in[1] tap_in[0] vdd vssx optlc_net_308 optlc_net_312 p_abuf0 p_abuf1 p_abuf2 p_abuf3 p_abuf4 p_abuf5 p_abuf6 optlc_net_313 optlc_net_318 optlc_net_319 optlc_net_320 optlc_net_321 optlc_net_322 optlc_net_323 p_abuf14 p_abuf15 buf_net_496 buf_net_476 buf_net_472 buf_net_472 trst_n trst_n buf_net_464 buf_net_510 buf_net_493 buf_net_471 buf_net_469 buf_net_468 buf_net_469 buf_net_483 buf_net_469 buf_net_469 buf_net_486 buf_net_509 buf_net_466 buf_net_482 buf_net_474 buf_net_474 buf_net_499 buf_net_475 buf_net_474 buf_net_466 buf_net_467 trst_n buf_net_497 buf_net_479 buf_net_473 buf_net_511 buf_net_470 buf_net_465 buf_net_467 buf_net_467 buf_net_470 buf_net_491 buf_net_496 buf_net_482 buf_net_467 trst_n buf_net_485 trst_n buf_net_497 buf_net_495 buf_net_492 buf_net_492 buf_net_514 buf_net_470 buf_net_494 buf_net_494 buf_net_492 buf_net_499 optlc_net_324 optlc_net_325 optlc_net_327 optlc_net_328 optlc_net_329 optlc_net_331 optlc_net_333 optlc_net_334 optlc_net_335 optlc_net_336 optlc_net_337 optlc_net_338 optlc_net_339 optlc_net_340 optlc_net_341 optlc_net_342 optlc_net_343 optlc_net_344 optlc_net_345 optlc_net_346 optlc_net_347 optlc_net_348 optlc_net_349 optlc_net_350 optlc_net_351 optlc_net_352 optlc_net_353 optlc_net_354 optlc_net_355 optlc_net_356 optlc_net_357 optlc_net_359 optlc_net_360 optlc_net_361 optlc_net_362 optlc_net_363 optlc_net_365 optlc_net_366 optlc_net_367 optlc_net_368 optlc_net_369 optlc_net_371 optlc_net_372 optlc_net_373 optlc_net_374 optlc_net_375 optlc_net_376 optlc_net_377 optlc_net_378 optlc_net_379 optlc_net_380 p_abuf7 p_abuf8 p_abuf9 p_abuf10 p_abuf11 p_abuf12 p_abuf13 p_abuf16 p_abuf17 buf_net_470 buf_net_477 buf_net_478 buf_net_480 buf_net_496 buf_net_484 buf_net_485 buf_net_487 buf_net_488 buf_net_489 buf_net_490 buf_net_492 buf_net_493 trst_n buf_net_503 buf_net_504 buf_net_505 buf_net_506 buf_net_507 buf_net_508 buf_net_512 buf_net_513 buf_net_515 buf_net_516 buf_net_517 ctsbuf_net_20553 ctsbuf_net_21554 ctsbuf_net_22555 ctsbuf_net_23556 ctsbuf_net_24557 ctsbuf_net_25558 ctsbuf_net_26559 optlc_net_561 ringpll__tcu_tpsb_stap_data_reg_269_0_1
Xplace_ainv_p_545 buf_net_521 buf_net_475 vdd vssx ringpll__b15inv000ah1n03x5 m=1
Xplace_ainv_p_559 buf_net_520 buf_net_489 vdd vssx ringpll__b15inv000al1n02x5 m=1
Xcts_cts_buf_10671825 tck ctsbuf_net_24557 vdd vssx ringpll__b15cbf000ah1n24x5 m=1
Xcts_cts_buf_10661824 tck ctsbuf_net_26559 vdd vssx ringpll__b15cbf000ah1n24x5 m=1
Xcts_cts_buf_10651823 tck ctsbuf_net_25558 vdd vssx ringpll__b15cbf000ah1n24x5 m=1
Xcts_cts_buf_10711829 tck ctsbuf_net_23556 vdd vssx ringpll__b15cbf000ah1n16x5 m=1
Xcts_cts_buf_10701828 tck ctsbuf_net_21554 vdd vssx ringpll__b15cbf000ah1n16x5 m=1
Xcts_cts_buf_10691827 tck ctsbuf_net_20553 vdd vssx ringpll__b15cbf000ah1n16x5 m=1
Xcts_cts_buf_10681826 tck ctsbuf_net_22555 vdd vssx ringpll__b15cbf000ah1n16x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_vcotopx2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_vcotopx2 clkout vro cb[2] cb[1] cb[0] en fz_spare pcsdegen[2] pcsdegen[1] pcsdegen[0] pgb[3] pgb[2] pgb[1] pgb[0] pvdivrat[1] pvdivrat[0] vccpll vcosel vctl vssx
* .PININFO cb[2]:I cb[1]:I cb[0]:I en:I fz_spare:I pcsdegen[2]:I pcsdegen[1]:I pcsdegen[0]:I pgb[3]:I pgb[2]:I pgb[1]:I pgb[0]:I pvdivrat[1]:I
* .PININFO pvdivrat[0]:I vccpll:I vcosel:I vctl:I vssx:I clkout:O vro:O
Xi26 vro vrolp_nom vcosel vccpll vssx ringpll__pll_lfmux
Xi6 vro vrolj_nom vcoselb vccpll vssx ringpll__pll_lfmux
Xinv00 vcosel vcoselb vccpll vssx ringpll__b15inv000al1n04x5 m=1
Xiljvco clklj vrolj_nom cb[2] cb[1] cb[0] enlj pcsdegen2 pcsdegen[1] pcsdegen[0] pgb3 pgb[2] pgb[1] pgb[0] pvdivrat[1] pvdivrat[0] vccpll vctl vssx ringpll__vcotop_lj
Xand00 en vcosel enlj vccpll vssx ringpll__b15and002al1n02x5 m=1
Xand01 en vcoselb enlp vccpll vssx ringpll__b15and002al1n02x5 m=1
Xorn01 override pgb[3] pgb3 vccpll vssx ringpll__b15orn002al1n03x5 m=1
Xorn00 override pcsdegen[2] pcsdegen2 vccpll vssx ringpll__b15orn002al1n03x5 m=1
Xmbn01 clklp clklj clkout vcoselb vccpll vssx ringpll__b15cmbn22ah1n12x5 m=1
Xnor00 pcsdegen[2] pcsdegen[1] pcsdegen[0] override vccpll vssx ringpll__b15nor003al1n03x5 m=1
Xivco clklp vrolp_nom cb[2] cb[1] cb[0] enlp pcsdegen2 pcsdegen[1] pcsdegen[0] pgb3 pgb[2] pgb[1] pgb[0] pvdivrat[1] pvdivrat[0] vccpll vctl vssx ringpll__vcotop
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_refdiv2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_refdiv2 clkout clkin mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] rstb tightloop vccxx vssx
* .PININFO clkin:I mdiv_ratio[5]:I mdiv_ratio[4]:I mdiv_ratio[3]:I mdiv_ratio[2]:I mdiv_ratio[1]:I mdiv_ratio[0]:I rstb:I tightloop:I vccxx:I vssx:I
* .PININFO clkout:O
Xirefdiv clkout divbygt1 clk2div vssx vssx vssx vssx vssx mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] rat0 vssx vccxx vssx rstb ringpll__pll_clkdiv
Xand00 clkin selnodelb net20 vccxx vssx ringpll__b15and002ah1n02x5 m=1
Xinv01 selnodelb selnodel vccxx vssx ringpll__b15inv000al1n04x5 m=1
Xbfm43 net19 net18 vccxx vssx ringpll__b15bfm402al1n04x5 m=1
Xbfm42 net20 net19 vccxx vssx ringpll__b15bfm402al1n04x5 m=1
Xbfm20 net18 net17 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xmbn00 clkin net17 clk2div selnodel vccxx vssx ringpll__b15mbn022al1n04x5 m=1
Xnor01 tightloop divbygt1 selnodelb vccxx vssx ringpll__b15nor002al1n04x5 m=1
Xinv00 divbygt1 net16 vccxx vssx ringpll__b15inv000al1n02x5 m=1
Xorn00 mdiv_ratio[0] net16 rat0 vccxx vssx ringpll__b15orn002al1n02x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    adc_sdmodtop
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__adc_sdmodtop adcdigoutx1nnnh[9] adcdigoutx1nnnh[8] adcdigoutx1nnnh[7] adcdigoutx1nnnh[6] adcdigoutx1nnnh[5] adcdigoutx1nnnh[4] adcdigoutx1nnnh[3] adcdigoutx1nnnh[2] adcdigoutx1nnnh[1] adcdigoutx1nnnh[0] adcdonex1nnnh adcchopennnnnh adcclkdivnnnnh[1] adcclkdivnnnnh[0] adcennnnnh adcfreezennnnh adcrstnnnnh_b clkinxh sdinpos_a vcchv vccxx vref_a vssx
* .PININFO adcchopennnnnh:I adcclkdivnnnnh[1]:I adcclkdivnnnnh[0]:I adcennnnnh:I adcfreezennnnh:I adcrstnnnnh_b:I clkinxh:I sdinpos_a:I vcchv:I
* .PININFO vccxx:I vref_a:I vssx:I adcdigoutx1nnnh[9]:O adcdigoutx1nnnh[8]:O adcdigoutx1nnnh[7]:O adcdigoutx1nnnh[6]:O adcdigoutx1nnnh[5]:O
* .PININFO adcdigoutx1nnnh[4]:O adcdigoutx1nnnh[3]:O adcdigoutx1nnnh[2]:O adcdigoutx1nnnh[1]:O adcdigoutx1nnnh[0]:O adcdonex1nnnh:O
Xiclkdiv bgtrimsync ckoutang adcen_dly ckph1 ckx1clk_buf adcclkdivnnnnh[1] adcclkdivnnnnh[0] en vccxx vssx ringpll__adc_cclkdiv
Xi60 n17 n18 vccxx vssx ringpll__b15bfm201al1n02x5 m=1
Xi59 n18 net21 vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xi72_1 sdmod sdmod_dly vccxx vssx ringpll__b15bfm201al1n04x5 m=1
Xiclkdrv ckdig ckph1 ckph2 ckoutang ckph1d_fb ckph2d_fb freeze_sync vccxx vssx ringpll__adc_novclkgen
Xidigbackend ckdigoutvalu2nxx digoutu700h[9] digoutu700h[8] digoutu700h[7] digoutu700h[6] digoutu700h[5] digoutu700h[4] digoutu700h[3] digoutu700h[2] digoutu700h[1] digoutu700h[0] adcdonex1nnnh ckdig bgtrimsync sdmod_dly vccxx vssx ringpll__adc_digtop
Xlan0 ckph1 net21 n16 vccxx vssx ringpll__b15lsn080al1n04x5 m=1
Xfqn00[9] net54 digoutu700h[9] adcdigoutx1nnnh[9] adcen_dly vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xfqn00[8] net54 digoutu700h[8] adcdigoutx1nnnh[8] adcen_dly vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xfqn00[7] net54 digoutu700h[7] adcdigoutx1nnnh[7] adcen_dly vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xfqn00[6] net54 digoutu700h[6] adcdigoutx1nnnh[6] adcen_dly vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xfqn00[5] net54 digoutu700h[5] adcdigoutx1nnnh[5] adcen_dly vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xfqn00[4] net54 digoutu700h[4] adcdigoutx1nnnh[4] adcen_dly vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xfqn00[3] net54 digoutu700h[3] adcdigoutx1nnnh[3] adcen_dly vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xfqn00[2] net54 digoutu700h[2] adcdigoutx1nnnh[2] adcen_dly vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xfqn00[1] net54 digoutu700h[1] adcdigoutx1nnnh[1] adcen_dly vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xfqn00[0] net54 digoutu700h[0] adcdigoutx1nnnh[0] adcen_dly vccxx vssx ringpll__b15fqn003al1n08x5 m=1
Xi73 adcchopennnnnh chhopen_dly vccxx vssx ringpll__b15bfn001al1n06x5 m=1
Xbfn1 adcennnnnh adcen_dly vccxx vssx ringpll__b15bfn001al1n06x5 m=1
Xclbi0 ckdigoutvalu2nxx net54 net21 vccxx vssx ringpll__b15clbia2al1n16x5 m=1
Xisdoutff sdmodfdbk sdmod chhopen_dly ckph1 sdmodout_ang vccxx vssx ringpll__adc_doutff
Xinn1 en en_b vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xi64 n13 en vccxx vssx ringpll__b15inv000al1n06x5 m=1
Xi71_1 clkinxh ckx1clk_buf vccxx vssx ringpll__b15bfn000al1n04x5 m=1
Xi65 adcrstnnnnh_b n13 vccxx vssx ringpll__b15inv000al1n04x5 m=1
Xi61 n16 freeze_sync vccxx vssx ringpll__b15inv000al1n04x5 m=1
Xi63 adcfreezennnnh freeze_b vccxx vssx ringpll__b15inv000al1n04x5 m=1
Xisdmodana ckph1d_fb ckph2d_fb sdmodout_ang chhopen_dly ckph1 ckph2 en_b sdmodfdbk sdinpos_a vcchv vccxx vref_a vssx ringpll__adc_sdmodana
Xfmy20 ckph1 freeze_b n17 vccxx vccxx vccxx vssx ringpll__b15fmy200al1n04x5 m=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ip22_ldopllpgd_core
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ip22_ldopllpgd_core analog_debug_out_o vdd_ldo_out_o vfb vfb_dft vref_dft d_fast_start_i d_ldo_bypass_i d_ldo_en_1p24v d_ldo_en_hicurrent_i d_ldo_extrefsel_i d_ldo_fbtrim_i[3] d_ldo_fbtrim_i[2] d_ldo_fbtrim_i[1] d_ldo_fbtrim_i[0] d_ldo_hiz_debug_i d_ldo_idq_debug_i d_ldo_pon_i d_ldo_reftrim_i[3] d_ldo_reftrim_i[2] d_ldo_reftrim_i[1] d_ldo_reftrim_i[0] d_refclk_i lp_brk_amp powergood_bar_vddh v_ref_i vddh vddl vssx fz_spare_4_strong_ladder_en powergood_vddl
* .PININFO d_fast_start_i:I d_ldo_bypass_i:I d_ldo_en_1p24v:I d_ldo_en_hicurrent_i:I d_ldo_extrefsel_i:I d_ldo_fbtrim_i[3]:I d_ldo_fbtrim_i[2]:I
* .PININFO d_ldo_fbtrim_i[1]:I d_ldo_fbtrim_i[0]:I d_ldo_hiz_debug_i:I d_ldo_idq_debug_i:I d_ldo_pon_i:I d_ldo_reftrim_i[3]:I d_ldo_reftrim_i[2]:I
* .PININFO d_ldo_reftrim_i[1]:I d_ldo_reftrim_i[0]:I d_refclk_i:I fz_spare_4_strong_ladder_en:I lp_brk_amp:I powergood_bar_vddh:I powergood_vddl:I
* .PININFO v_ref_i:I vddh:I vddl:I vssx:I analog_debug_out_o:O vdd_ldo_out_o:O vfb:O vfb_dft:O vref_dft:O
Xiref vref_int en_1p24v pon_byp ladder1_reftrim[3] ladder1_reftrim[2] ladder1_reftrim[1] ladder1_reftrim[0] start_pulse vcchv_gated vddl vssx ringpll__x22heldo_refgen
Ximux vref d_ldo_extrefsel_i ext_vref_int vref_int vddl vssx ringpll__x22lpldo_2inmuxana
Xipowergate pon_b2 vddh vcchv_gated ringpll__x22imc_powergate
Xi146 vfb_dft vfb debugen vddl vssx ringpll__x22ldo_dftamp
Xi145 vref_dft ref_filt debugen vddl vssx ringpll__x22ldo_dftamp
Xor02 startpulse_nv fz_spare_4_strong_ladder_en strng_ladder vddl vssx ringpll__b15orn002al1n12x5 m=1
Xibias bias byp en_hicurrent pon vcchv_gated ref_filt vssx ringpll__x22ldo_pll_bias_highcurrent
Xu1772 dften_b vcchv_gated vssx debugen pon ringpll__xb15nand02xu1n12x5
Xi0 ext_vref_0p6v soft_vddh powergood_vddl ladder2_reftrim[3] ladder2_reftrim[2] ladder2_reftrim[1] ladder2_reftrim[0] strng_ladder_vddh vddh vddl vssx v_ref_i ringpll__x22heldo_refgen_1v_to_0p6v
Xilpf vref ref_filt startpulse_nv vddl vssx ringpll__x22heldo_lpf
Xicontrol pon_byp_nv startpulse_nv d_fast_start_i d_ldo_bypass_i d_ldo_pon_i d_refclk_i vddl vssx ringpll__x22ldo_nvcontrol
Xresdiv1 vfb net103[3] net103[2] net103[1] net103[0] vdd_ldo_out_o vssx ringpll__x22heldo_fbdiv
Xi239 vdd_ldo_out_o vssx ringpll__x22ldo_decap1
Xi152 vdd_ldo_out_o vssx ringpll__x22ldo_decap3
Xand00 powergood_buf_vddl strng_ladder strng_ladder_vddl vddl vssx ringpll__b15and002al1n12x5 m=1
Xand03 d_ldo_pon_i d_fast_start_i flop_rst vddl vssx ringpll__b15and002al1n12x5 m=1
Xinv03[9] pon_b2 vddh vssx pon2 ringpll__xb15inv000xu1n20x5
Xinv03[8] pon_b2 vddh vssx pon2 ringpll__xb15inv000xu1n20x5
Xinv03[7] pon_b2 vddh vssx pon2 ringpll__xb15inv000xu1n20x5
Xinv03[6] pon_b2 vddh vssx pon2 ringpll__xb15inv000xu1n20x5
Xinv03[5] pon_b2 vddh vssx pon2 ringpll__xb15inv000xu1n20x5
Xinv03[4] pon_b2 vddh vssx pon2 ringpll__xb15inv000xu1n20x5
Xinv03[3] pon_b2 vddh vssx pon2 ringpll__xb15inv000xu1n20x5
Xinv03[2] pon_b2 vddh vssx pon2 ringpll__xb15inv000xu1n20x5
Xinv03[1] pon_b2 vddh vssx pon2 ringpll__xb15inv000xu1n20x5
Xinv02[3] pon2 vddh vssx pon_b ringpll__xb15inv000xu1n20x5
Xinv02[2] pon2 vddh vssx pon_b ringpll__xb15inv000xu1n20x5
Xinv02[1] pon2 vddh vssx pon_b ringpll__xb15inv000xu1n20x5
Xinv01 pon_b vddh vssx pon ringpll__xb15inv000xu1n20x5
Xidften[10] analog_debug_out_o dften_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidften[9] analog_debug_out_o dften_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidften[8] analog_debug_out_o dften_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidften[7] analog_debug_out_o dften_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidften[6] analog_debug_out_o dften_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidften[5] analog_debug_out_o dften_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidften[4] analog_debug_out_o dften_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidften[3] analog_debug_out_o dften_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidften[2] analog_debug_out_o dften_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidften[1] analog_debug_out_o dften_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftven[10] vdd_ldo_out_o current_out debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftven[9] vdd_ldo_out_o current_out debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftven[8] vdd_ldo_out_o current_out debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftven[7] vdd_ldo_out_o current_out debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftven[6] vdd_ldo_out_o current_out debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftven[5] vdd_ldo_out_o current_out debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftven[4] vdd_ldo_out_o current_out debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftven[3] vdd_ldo_out_o current_out debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftven[2] vdd_ldo_out_o current_out debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftven[1] vdd_ldo_out_o current_out debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftien[10] test_out testen_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftien[9] test_out testen_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftien[8] test_out testen_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftien[7] test_out testen_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftien[6] test_out testen_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftien[5] test_out testen_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftien[4] test_out testen_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftien[3] test_out testen_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftien[2] test_out testen_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xidftien[1] test_out testen_b debug vcchv_gated ringpll__x22imc_ana_p216_mult4_tg m=1
Xi_238 vdd_ldo_out_o vssx ringpll__x22ldo_decap2
Xi48 net0114 startup_refclk_div4 flop_rst vddl vssx ringpll__x22lpldo_cnt_bit
Xibit1 startup_refclk_div2 d_refclk_i flop_rst vddl vssx ringpll__x22lpldo_cnt_bit
Xi43 startup_refclk_div4 startup_refclk_div2 flop_rst vddl vssx ringpll__x22lpldo_cnt_bit
Xiamp test_out vdd_ldo_out_o bias byp pon testen_b start_pulse vfb lp_brk_amp ref_filt vcchv_gated vssx ringpll__x22ldo_pll_main_singleamp
Xinvextsel d_ldo_extrefsel_i inv_extsel vddl vssx ringpll__b15inv000al1n04x5 m=1
Xsg005 strng_ladder_vddl powergood_bar_vddh strng_ladder_vddh vddl vddh vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg0011 d_ldo_en_1p24v powergood_bar_vddh en_1p24v vddl vddh vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg008 startpulse_nv powergood_bar_vddh start_pulse vddl vddh vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg001 d_ldo_idq_debug_i powergood_bar_vddh current_out vddl vddh vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg0010 pon_byp_nv powergood_bar_vddh pon_byp vddl vddh vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg0012 d_ldo_en_hicurrent_i powergood_bar_vddh en_hicurrent vddl vddh vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg003 d_ldo_bypass_i powergood_bar_vddh byp vddl vddh vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg000 d_ldo_hiz_debug_i powergood_bar_vddh debugen vddl vddh vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg002 d_ldo_pon_i powergood_bar_vddh pon vddl vddh vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg004[3] d_ldo_fbtrim_i[3] powergood_bar_vddh net103[3] vddl vdd_ldo_out_o vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg004[2] d_ldo_fbtrim_i[2] powergood_bar_vddh net103[2] vddl vdd_ldo_out_o vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg004[1] d_ldo_fbtrim_i[1] powergood_bar_vddh net103[1] vddl vdd_ldo_out_o vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xsg004[0] d_ldo_fbtrim_i[0] powergood_bar_vddh net103[0] vddl vdd_ldo_out_o vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
Xand_ladder2[3] d_ldo_reftrim_i[3] d_ldo_extrefsel_i ladder2_reftrim[3] vddl vssx ringpll__b15and002al1n04x5 m=1
Xand_ladder2[2] d_ldo_reftrim_i[2] d_ldo_extrefsel_i ladder2_reftrim[2] vddl vssx ringpll__b15and002al1n04x5 m=1
Xand_ladder2[1] d_ldo_reftrim_i[1] d_ldo_extrefsel_i ladder2_reftrim[1] vddl vssx ringpll__b15and002al1n04x5 m=1
Xand_ladder2[0] d_ldo_reftrim_i[0] d_ldo_extrefsel_i ladder2_reftrim[0] vddl vssx ringpll__b15and002al1n04x5 m=1
Xand_ladder1[3] d_ldo_reftrim_i[3] inv_extsel ladder1_reftrim[3] vddl vssx ringpll__b15and002al1n04x5 m=1
Xand_ladder1[2] d_ldo_reftrim_i[2] inv_extsel ladder1_reftrim[2] vddl vssx ringpll__b15and002al1n04x5 m=1
Xand_ladder1[1] d_ldo_reftrim_i[1] inv_extsel ladder1_reftrim[1] vddl vssx ringpll__b15and002al1n04x5 m=1
Xand_ladder1[0] d_ldo_reftrim_i[0] inv_extsel ladder1_reftrim[0] vddl vssx ringpll__b15and002al1n04x5 m=1
Xcmbn0 startup_refclk_div4 d_refclk_i net0120 d_ldo_extrefsel_i vddl vssx ringpll__b15cmbn22al1n04x5 m=1
Xtihi1[1] soft_vddh vddh vssx ringpll__b15tihi00ag1n03x5 m=1
Xtihi1[0] soft_vddh vddh vssx ringpll__b15tihi00ag1n03x5 m=1
Xtihi0[1] soft_vddl vddl vssx ringpll__b15tihi00an1n03x5 m=1
Xtihi0[0] soft_vddl vddl vssx ringpll__b15tihi00an1n03x5 m=1
Xinv06 soft_vddl soft_vssx vddl vssx ringpll__b15inv000an1n10x5 m=1
Xipglu1 ext_vref_int ext_vref_0p6v vddl vssx ringpll__x22thmpassg4lu
Xinv00 testen_b vcchv_gated vssx current_out ringpll__xb15inv000xu1n05x5
Xbfn00 powergood_vddl powergood_buf_vddl vddl vssx ringpll__b15bfn000al1n12x5 m=1
Mmp0[23] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[22] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[21] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[20] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[19] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[18] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[17] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[16] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[15] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[14] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[13] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[12] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[11] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[10] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[9] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[8] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[7] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[6] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[5] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[4] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[3] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[2] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[1] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
Mmp0[0] debug debug debug vcchv_gated ptgmv W=180n L=120n M=1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljplldac
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljplldac dacout dac_on dac_trim[3] dac_trim[2] dac_trim[1] dac_trim[0] vccxx vssx
* .PININFO dac_on:I dac_trim[3]:I dac_trim[2]:I dac_trim[1]:I dac_trim[0]:I vccxx:I vssx:I dacout:O
Xreslad_logic enn_nc tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 dac_on vccxx vssx ringpll__pllx22ljplldac_res_logic
Xifbmux dacout tap0 tap1 tap2 tap3 tap4 tap5 tap6 tap7 tap8 tap9 tap10 tap11 tap12 tap13 tap14 tap15 dac_trim[3] dac_trim[2] dac_trim[1] dac_trim[0] vccxx vssx ringpll__pllx22ljpll_fbmux_v2
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pllx22ljpll_pfd_cp
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pllx22ljpll_pfd_cp lockrst pbias tup vctl chopen cp_en cpintscan[4] cpintscan[3] cpintscan[2] cpintscan[1] cpintscan[0] disablepfdpwrgate fbclk iref lockthresh[1] lockthresh[0] nbiastrim[1] nbiastrim[0] pfd_en pfdresipw[2] pfdresipw[1] pfdresipw[0] pgatedlytrim[1] pgatedlytrim[0] refclk vccpll vssx
* .PININFO chopen:I cp_en:I cpintscan[4]:I cpintscan[3]:I cpintscan[2]:I cpintscan[1]:I cpintscan[0]:I disablepfdpwrgate:I fbclk:I iref:I
* .PININFO lockthresh[1]:I lockthresh[0]:I nbiastrim[1]:I nbiastrim[0]:I pfd_en:I pfdresipw[2]:I pfdresipw[1]:I pfdresipw[0]:I pgatedlytrim[1]:I
* .PININFO pgatedlytrim[0]:I refclk:I vccpll:I vssx:I lockrst:O pbias:O tup:O vctl:O
Xicp pbias vctl iref cpintscan[0] cpintscan[1] cpintscan[2] cpintscan[3] cpintscan[4] cppwgate cpdn cp_en nbiastrim[1] nbiastrim[0] cpup vccpll vssx ringpll__pllx22ljcpi_jsa
Xipfd cppwgate lockrst cpup cpdn tup chopen disablepfdpwrgate fbclk vssx lockthresh[1] lockthresh[0] pfd_en pgatedlytrim[1] pgatedlytrim[0] refclk pfdresipw[2] pfdresipw[1] pfdresipw[0] vccpll vssx ringpll__pllx22_cnlx74ljpllpwrgatepfd
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_anadft
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_anadft adc_in viewanabus[1] viewanabus[0] vctl adc_sel_in[2] adc_sel_in[1] adc_sel_in[0] anadft_ldo anadft_ldovfb anadft_ldovref iref_view pbias rdactovctlen vccdig vccpll vccvdd2 vctlrdac[3] vctlrdac[2] vctlrdac[1] vctlrdac[0] vctlrdacen viewanaen[1] viewanaen[0] vro vssx
* .PININFO adc_sel_in[2]:I adc_sel_in[1]:I adc_sel_in[0]:I anadft_ldo:I anadft_ldovfb:I anadft_ldovref:I iref_view:I pbias:I rdactovctlen:I vccdig:I
* .PININFO vccpll:I vccvdd2:I vctlrdac[3]:I vctlrdac[2]:I vctlrdac[1]:I vctlrdac[0]:I vctlrdacen:I viewanaen[1]:I viewanaen[0]:I vro:I vssx:I adc_in:O
* .PININFO viewanabus[1]:O viewanabus[0]:O vctl:B
Xiesd[1] viewanabus[1] anadft_ldo vccvdd2 vssx ringpll__pll_esdd3d4
Xiesd[0] viewanabus[0] viewanabus_i[0] vccvdd2 vssx ringpll__pll_esdd3d4
Xidac dacout vctlrdacen vctlrdac[3] vctlrdac[2] vctlrdac[1] vctlrdac[0] vccpll vssx ringpll__pllx22ljplldac
Xivctlmux vctl dacout rdactovctlen vccpll vssx ringpll__pll_anamux
Xitgmux0 viewanabus_i[0] adc_in viewanaen[0] vccvdd2 vccdig vssx ringpll__pll_anamuxtg
Xitgmux1 anadft_ldo iref_view viewanaen[1] vccvdd2 vccdig vssx ringpll__pll_anamuxtg
Xiadcmux adc_in vssx pbias vctl vro vccpll vssx anadft_ldovfb anadft_ldovref adc_sel_in[2] adc_sel_in[1] adc_sel_in[0] vccpll vssx ringpll__pll_anamux8
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_viewadc2
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_viewadc2 adc_dig_out[9] adc_dig_out[8] adc_dig_out[7] adc_dig_out[6] adc_dig_out[5] adc_dig_out[4] adc_dig_out[3] adc_dig_out[2] adc_dig_out[1] adc_dig_out[0] adc_done adc_chop_en adc_clkdiv[1] adc_clkdiv[0] adc_freeze adc_reset_bxxl adc_startxxh clkrefxxh pll_core_adc_in vccpll_nom vccvdd2 vssx
* .PININFO adc_chop_en:I adc_clkdiv[1]:I adc_clkdiv[0]:I adc_freeze:I adc_reset_bxxl:I adc_startxxh:I clkrefxxh:I pll_core_adc_in:I vccpll_nom:I
* .PININFO vccvdd2:I vssx:I adc_dig_out[9]:O adc_dig_out[8]:O adc_dig_out[7]:O adc_dig_out[6]:O adc_dig_out[5]:O adc_dig_out[4]:O adc_dig_out[3]:O
* .PININFO adc_dig_out[2]:O adc_dig_out[1]:O adc_dig_out[0]:O adc_done:O
Xiadc adc_dig_out[9] adc_dig_out[8] adc_dig_out[7] adc_dig_out[6] adc_dig_out[5] adc_dig_out[4] adc_dig_out[3] adc_dig_out[2] adc_dig_out[1] adc_dig_out[0] adc_done adc_chop_en adc_clkdiv[1] adc_clkdiv[0] adc_startxxh adc_freeze adc_reset_bxxl clkrefxxh pll_core_adc_in vccvdd2 vccpll_nom vccvdd2 vssx ringpll__adc_sdmodtop
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ip22_ldopllpgd
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ip22_ldopllpgd analog_debug_out_o vdd_ldo_out_o vfb_dft vref_dft d_fast_start_i d_ldo_bypass_i d_ldo_en_1p24v d_ldo_en_hicurrent_i d_ldo_extrefsel_i d_ldo_fbtrim_i[3] d_ldo_fbtrim_i[2] d_ldo_fbtrim_i[1] d_ldo_fbtrim_i[0] d_ldo_hiz_debug_i d_ldo_idq_debug_i d_ldo_pon_i d_ldo_reftrim_i[3] d_ldo_reftrim_i[2] d_ldo_reftrim_i[1] d_ldo_reftrim_i[0] d_refclk_i powergood_bar_vddh v_ref_i vddh vddl vssx fz_spare_4_strong_ladder_en powergood_vddl
* .PININFO d_fast_start_i:I d_ldo_bypass_i:I d_ldo_en_1p24v:I d_ldo_en_hicurrent_i:I d_ldo_extrefsel_i:I d_ldo_fbtrim_i[3]:I d_ldo_fbtrim_i[2]:I
* .PININFO d_ldo_fbtrim_i[1]:I d_ldo_fbtrim_i[0]:I d_ldo_hiz_debug_i:I d_ldo_idq_debug_i:I d_ldo_pon_i:I d_ldo_reftrim_i[3]:I d_ldo_reftrim_i[2]:I
* .PININFO d_ldo_reftrim_i[1]:I d_ldo_reftrim_i[0]:I d_refclk_i:I fz_spare_4_strong_ladder_en:I powergood_bar_vddh:I powergood_vddl:I v_ref_i:I vddh:I
* .PININFO vddl:I vssx:I analog_debug_out_o:O vdd_ldo_out_o:O vfb_dft:O vref_dft:O
Xildo_core analog_debug_out_o vdd_ldo_out_o net21 vfb_dft vref_dft d_fast_start_i d_ldo_bypass_i d_ldo_en_1p24v d_ldo_en_hicurrent_i d_ldo_extrefsel_i d_ldo_fbtrim_i[3] d_ldo_fbtrim_i[2] d_ldo_fbtrim_i[1] d_ldo_fbtrim_i[0] d_ldo_hiz_debug_i d_ldo_idq_debug_i d_ldo_pon_i d_ldo_reftrim_i[3] d_ldo_reftrim_i[2] d_ldo_reftrim_i[1] d_ldo_reftrim_i[0] d_refclk_i net21 powergood_bar_vddh v_ref_i vddh vddl vssx fz_spare_4_strong_ladder_en powergood_vddl ringpll__ip22_ldopllpgd_core
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_ldo
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_ldo anadft_ldovfb anadft_ldovref vccpll viewana clkref fz_ldo_bypass fz_ldo_extrefsel fz_ldo_faststart fz_ldo_fbtrim[3] fz_ldo_fbtrim[2] fz_ldo_fbtrim[1] fz_ldo_fbtrim[0] fz_ldo_reftrim[3] fz_ldo_reftrim[2] fz_ldo_reftrim[1] fz_ldo_reftrim[0] fz_ldo_vinvoltsel[1] fz_ldo_vinvoltsel[0] ldo_enable ldo_vref powergood_vnn ta_ldo_hiz_debug ta_ldo_idq_debug vccdig vccldo vnnaon_nom vssx fz_spare_4_strong_ladder_en powergood_vccdig
* .PININFO clkref:I fz_ldo_bypass:I fz_ldo_extrefsel:I fz_ldo_faststart:I fz_ldo_fbtrim[3]:I fz_ldo_fbtrim[2]:I fz_ldo_fbtrim[1]:I fz_ldo_fbtrim[0]:I
* .PININFO fz_ldo_reftrim[3]:I fz_ldo_reftrim[2]:I fz_ldo_reftrim[1]:I fz_ldo_reftrim[0]:I fz_ldo_vinvoltsel[1]:I fz_ldo_vinvoltsel[0]:I
* .PININFO fz_spare_4_strong_ladder_en:I ldo_enable:I ldo_vref:I powergood_vccdig:I powergood_vnn:I ta_ldo_hiz_debug:I ta_ldo_idq_debug:I vccdig:I
* .PININFO vccldo:I vnnaon_nom:I vssx:I anadft_ldovfb:O anadft_ldovref:O vccpll:O viewana:O
Xildo viewana vccpll net37 net36 fz_ldo_faststart fz_ldo_bypass fz_ldo_vinvoltselb[0] fz_ldo_vinvoltselb[1] fz_ldo_extrefsel fbtrim[3] fbtrim[2] fbtrim[1] fbtrim[0] ta_ldo_hiz_debug ta_ldo_idq_debug ldo_enable reftrim[3] reftrim[2] reftrim[1] reftrim[0] clkref powergood_bar_vddh ldo_vref vccldo vccdig vssx fz_spare_4_strong_ladder_en powergood_vccdig ringpll__ip22_ldopllpgd
Xorn02[3] refovrd fz_ldo_reftrim[3] reftrim[3] vccdig vssx ringpll__b15orn002al1n04x5 m=1
Xorn02[2] vssx fz_ldo_reftrim[2] reftrim[2] vccdig vssx ringpll__b15orn002al1n04x5 m=1
Xorn02[1] vssx fz_ldo_reftrim[1] reftrim[1] vccdig vssx ringpll__b15orn002al1n04x5 m=1
Xorn02[0] refovrd fz_ldo_reftrim[0] reftrim[0] vccdig vssx ringpll__b15orn002al1n04x5 m=1
Xorn00[3] fbovrd fz_ldo_fbtrim[3] fbtrim[3] vccdig vssx ringpll__b15orn002al1n04x5 m=1
Xorn00[2] vssx fz_ldo_fbtrim[2] fbtrim[2] vccdig vssx ringpll__b15orn002al1n04x5 m=1
Xorn00[1] vssx fz_ldo_fbtrim[1] fbtrim[1] vccdig vssx ringpll__b15orn002al1n04x5 m=1
Xorn00[0] fbovrd fz_ldo_fbtrim[0] fbtrim[0] vccdig vssx ringpll__b15orn002al1n04x5 m=1
Xinv03[1] fz_ldo_vinvoltsel[1] fz_ldo_vinvoltselb[1] vccdig vssx ringpll__b15inv000al1n06x5 m=1
Xinv03[0] fz_ldo_vinvoltsel[0] fz_ldo_vinvoltselb[0] vccdig vssx ringpll__b15inv000al1n06x5 m=1
Xinv00 ta_ldo_hiz_debug net31 vccdig vssx ringpll__b15inv000al1n06x5 m=1
Xnor01 fz_ldo_reftrim[3] fz_ldo_reftrim[2] fz_ldo_reftrim[1] fz_ldo_reftrim[0] refovrd vccdig vssx ringpll__b15nor004al1n03x5 m=1
Xnor00 fz_ldo_fbtrim[3] fz_ldo_fbtrim[2] fz_ldo_fbtrim[1] fz_ldo_fbtrim[0] fbovrd vccdig vssx ringpll__b15nor004al1n03x5 m=1
Mmn3 vssx net31 anadft_ldovref vssx n W=180n L=40n M=1
Mmn0 net37 ta_ldo_hiz_debug anadft_ldovfb vssx n W=180n L=40n M=4
Mmn1 vssx net31 anadft_ldovfb vssx n W=180n L=40n M=1
Mmn2 net36 ta_ldo_hiz_debug anadft_ldovref vssx n W=180n L=40n M=4
Mmp1 net36 net31 anadft_ldovref vccdig p W=180n L=40n M=4
Mmp0 net37 net31 anadft_ldovfb vccdig p W=180n L=40n M=4
Xinv01 powergood_bar_vddh vccldo vssx powergood_vddh ringpll__xb15inv000xu1n20x5
Xsg000 powergood_vnn vssx powergood_vddh vnnaon_nom vccldo vssx ringpll__ip22_ldopll_ls_mixedvt_p1stkmv_ip2211mtgldopllpgd_ihdk_sch
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    pll_ana
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__pll_ana adc_in clkout lockrst viewanabus[1] viewanabus[0] adc_sel_in[2] adc_sel_in[1] adc_sel_in[0] anadft_ldo anadft_ldovfb anadft_ldovref clkfb clkref fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] fz_cpnbias[1] fz_cpnbias[0] fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] fz_lockthresh[3] fz_lockthresh[2] fz_lockthresh[1] fz_lockthresh[0] fz_nopfdpwrgate fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] fz_pfddly[1] fz_pfddly[0] fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] fz_vcosel fz_vcotrim[10] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] pdivrat[1] pdivrat[0] pfden rdactovctlen reset_b vccdig vccpll vccvdd2 vctlrdac[3] vctlrdac[2] vctlrdac[1] vctlrdac[0] vctlrdacen viewanaen[1] viewanaen[0] vssx
* .PININFO adc_sel_in[2]:I adc_sel_in[1]:I adc_sel_in[0]:I anadft_ldo:I anadft_ldovfb:I anadft_ldovref:I clkfb:I clkref:I fz_cp1trim[4]:I
* .PININFO fz_cp1trim[3]:I fz_cp1trim[2]:I fz_cp1trim[1]:I fz_cp1trim[0]:I fz_cp2trim[4]:I fz_cp2trim[3]:I fz_cp2trim[2]:I fz_cp2trim[1]:I
* .PININFO fz_cp2trim[0]:I fz_cpnbias[1]:I fz_cpnbias[0]:I fz_irefgen[4]:I fz_irefgen[3]:I fz_irefgen[2]:I fz_irefgen[1]:I fz_irefgen[0]:I
* .PININFO fz_lockthresh[3]:I fz_lockthresh[2]:I fz_lockthresh[1]:I fz_lockthresh[0]:I fz_nopfdpwrgate:I fz_pfd_pw[2]:I fz_pfd_pw[1]:I fz_pfd_pw[0]:I
* .PININFO fz_pfddly[1]:I fz_pfddly[0]:I fz_skadj[4]:I fz_skadj[3]:I fz_skadj[2]:I fz_skadj[1]:I fz_skadj[0]:I fz_startup[5]:I fz_startup[4]:I
* .PININFO fz_startup[3]:I fz_startup[2]:I fz_startup[1]:I fz_startup[0]:I fz_vcosel:I fz_vcotrim[10]:I fz_vcotrim[9]:I fz_vcotrim[8]:I
* .PININFO fz_vcotrim[7]:I fz_vcotrim[6]:I fz_vcotrim[5]:I fz_vcotrim[4]:I fz_vcotrim[3]:I fz_vcotrim[2]:I fz_vcotrim[1]:I fz_vcotrim[0]:I
* .PININFO pdivrat[1]:I pdivrat[0]:I pfden:I rdactovctlen:I reset_b:I vccdig:I vccpll:I vccvdd2:I vctlrdac[3]:I vctlrdac[2]:I vctlrdac[1]:I
* .PININFO vctlrdac[0]:I vctlrdacen:I viewanaen[1]:I viewanaen[0]:I vssx:I adc_in:O clkout:O lockrst:O viewanabus[1]:O viewanabus[0]:O
Xistartup vctl0 reset_b clkfb_adj fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] rdactovctlen clkref_adj tup vccpll vssx ringpll__pll_startup
Xianadft adc_in viewanabus[1] viewanabus[0] vctl adc_sel_in[2] adc_sel_in[1] adc_sel_in[0] anadft_ldo anadft_ldovfb anadft_ldovref iref_view pbias rdactovctlen vccdig vccpll vccvdd2 vctlrdac[3] vctlrdac[2] vctlrdac[1] vctlrdac[0] vctlrdacen viewanaen[1] viewanaen[0] vro vssx ringpll__pll_anadft
Xiiref iref iref_view reset_b fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] vccpll vro vssx ringpll__pllx22aljiref2
Xivco clkout vro fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] reset_b fz_vcotrim[10] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] pdivrat[1] pdivrat[0] vccpll fz_vcosel vctl vssx ringpll__pll_vcotopx2
Xipfd_cp lockrst pbias tup vcp fz_lockthresh[3] reset_b fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_nopfdpwrgate clkfb_adj iref fz_lockthresh[1] fz_lockthresh[0] fz_cpnbias[1] fz_cpnbias[0] pfden fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] fz_pfddly[1] fz_pfddly[0] clkref_adj vccpll vssx ringpll__pllx22ljpll_pfd_cp
Xiskadj clkfb_adj clkref_adj clkfb clkref fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] vccpll vssx ringpll__pll_skewadjust2
Xilf vctl fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] vccpll vcp vctl0 vssx ringpll__pll_lf
Xic1 vccpll vctl0 vssx ringpll__pll_lfc1
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ip22_ringpll_hip
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll__ip22_ringpll_hip adc_dig_out[9] adc_dig_out[8] adc_dig_out[7] adc_dig_out[6] adc_dig_out[5] adc_dig_out[4] adc_dig_out[3] adc_dig_out[2] adc_dig_out[1] adc_dig_out[0] adc_done clkfbmxh clkidvih clkplldiv0 clkplldiv1 clkpllmh pfdlockrstnh viewanabusnh[1] viewanabusnh[0] viewoutnh[1] viewoutnh[0] adc_chop_en adc_clkdiv[1] adc_clkdiv[0] adc_freeze adc_reset_bxxl adc_sel_in[2] adc_sel_in[1] adc_sel_in[0] adc_startxxh adc_use_vref anadft_ldo anadft_ldovfb anadft_ldovref bypassenxxl bypassxxl clkpostdistmh clkrefxxh earlylockxxh fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] fz_cpnbias[1] fz_cpnbias[0] fz_dca_cb[1] fz_dca_cb[0] fz_dca_ctrl[5] fz_dca_ctrl[4] fz_dca_ctrl[3] fz_dca_ctrl[2] fz_dca_ctrl[1] fz_dca_ctrl[0] fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] fz_lockthresh[3] fz_lockthresh[2] fz_lockthresh[1] fz_lockthresh[0] fz_lpfclksel fz_nopfdpwrgate fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] fz_pfddly[1] fz_pfddly[0] fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] fz_spare[4] fz_spare[3] fz_spare[2] fz_spare[1] fz_spare[0] fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] fz_tight_loopb fz_vcosel fz_vcotrim[10] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] idv_gate_en lockxxl mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] mod_clk_to_view pfdennh powergood ratio[9] ratio[8] ratio[7] ratio[6] ratio[5] ratio[4] ratio[3] ratio[2] ratio[1] ratio[0] ratio_halfint ratiozdiv0[9] ratiozdiv0[8] ratiozdiv0[7] ratiozdiv0[6] ratiozdiv0[5] ratiozdiv0[4] ratiozdiv0[3] ratiozdiv0[2] ratiozdiv0[1] ratiozdiv0[0] ratiozdiv1[9] ratiozdiv1[8] ratiozdiv1[7] ratiozdiv1[6] ratiozdiv1[5] ratiozdiv1[4] ratiozdiv1[3] ratiozdiv1[2] ratiozdiv1[1] ratiozdiv1[0] rawlockxxl rdactovctlennh reset_b_xxl ssc_reload ta_spare[4] ta_spare[3] ta_spare[2] ta_spare[1] ta_spare[0] tllm_force_tight_loop tllm_gate_clk_trunk vccdig vccdist vccpll vccref vccvdd2 vcodiv_ratio[1] vcodiv_ratio[0] vctlrdacctlnh[3] vctlrdacctlnh[2] vctlrdacctlnh[1] vctlrdacctlnh[0] vctlrdacennl viewanaennh[1] viewanaennh[0] viewdigennh[1] viewdigennh[0] viewsel0[4] viewsel0[3] viewsel0[2] viewsel0[1] viewsel0[0] viewsel1[4] viewsel1[3] viewsel1[2] viewsel1[1] viewsel1[0] vssx zdiv0ratiop5 zdiv1ratiop5
* .PININFO adc_chop_en:I adc_clkdiv[1]:I adc_clkdiv[0]:I adc_freeze:I adc_reset_bxxl:I adc_sel_in[2]:I adc_sel_in[1]:I adc_sel_in[0]:I adc_startxxh:I
* .PININFO adc_use_vref:I anadft_ldo:I anadft_ldovfb:I anadft_ldovref:I bypassenxxl:I bypassxxl:I clkpostdistmh:I clkrefxxh:I earlylockxxh:I
* .PININFO fz_cp1trim[4]:I fz_cp1trim[3]:I fz_cp1trim[2]:I fz_cp1trim[1]:I fz_cp1trim[0]:I fz_cp2trim[4]:I fz_cp2trim[3]:I fz_cp2trim[2]:I
* .PININFO fz_cp2trim[1]:I fz_cp2trim[0]:I fz_cpnbias[1]:I fz_cpnbias[0]:I fz_dca_cb[1]:I fz_dca_cb[0]:I fz_dca_ctrl[5]:I fz_dca_ctrl[4]:I
* .PININFO fz_dca_ctrl[3]:I fz_dca_ctrl[2]:I fz_dca_ctrl[1]:I fz_dca_ctrl[0]:I fz_irefgen[4]:I fz_irefgen[3]:I fz_irefgen[2]:I fz_irefgen[1]:I
* .PININFO fz_irefgen[0]:I fz_lockthresh[3]:I fz_lockthresh[2]:I fz_lockthresh[1]:I fz_lockthresh[0]:I fz_lpfclksel:I fz_nopfdpwrgate:I fz_pfd_pw[2]:I
* .PININFO fz_pfd_pw[1]:I fz_pfd_pw[0]:I fz_pfddly[1]:I fz_pfddly[0]:I fz_skadj[4]:I fz_skadj[3]:I fz_skadj[2]:I fz_skadj[1]:I fz_skadj[0]:I
* .PININFO fz_spare[4]:I fz_spare[3]:I fz_spare[2]:I fz_spare[1]:I fz_spare[0]:I fz_startup[5]:I fz_startup[4]:I fz_startup[3]:I fz_startup[2]:I
* .PININFO fz_startup[1]:I fz_startup[0]:I fz_tight_loopb:I fz_vcosel:I fz_vcotrim[10]:I fz_vcotrim[9]:I fz_vcotrim[8]:I fz_vcotrim[7]:I
* .PININFO fz_vcotrim[6]:I fz_vcotrim[5]:I fz_vcotrim[4]:I fz_vcotrim[3]:I fz_vcotrim[2]:I fz_vcotrim[1]:I fz_vcotrim[0]:I idv_gate_en:I lockxxl:I
* .PININFO mdiv_ratio[5]:I mdiv_ratio[4]:I mdiv_ratio[3]:I mdiv_ratio[2]:I mdiv_ratio[1]:I mdiv_ratio[0]:I mod_clk_to_view:I pfdennh:I powergood:I
* .PININFO ratio[9]:I ratio[8]:I ratio[7]:I ratio[6]:I ratio[5]:I ratio[4]:I ratio[3]:I ratio[2]:I ratio[1]:I ratio[0]:I ratio_halfint:I
* .PININFO ratiozdiv0[9]:I ratiozdiv0[8]:I ratiozdiv0[7]:I ratiozdiv0[6]:I ratiozdiv0[5]:I ratiozdiv0[4]:I ratiozdiv0[3]:I ratiozdiv0[2]:I
* .PININFO ratiozdiv0[1]:I ratiozdiv0[0]:I ratiozdiv1[9]:I ratiozdiv1[8]:I ratiozdiv1[7]:I ratiozdiv1[6]:I ratiozdiv1[5]:I ratiozdiv1[4]:I
* .PININFO ratiozdiv1[3]:I ratiozdiv1[2]:I ratiozdiv1[1]:I ratiozdiv1[0]:I rawlockxxl:I rdactovctlennh:I reset_b_xxl:I ssc_reload:I ta_spare[4]:I
* .PININFO ta_spare[3]:I ta_spare[2]:I ta_spare[1]:I ta_spare[0]:I tllm_force_tight_loop:I tllm_gate_clk_trunk:I vccdig:I vccdist:I vccpll:I vccref:I
* .PININFO vccvdd2:I vcodiv_ratio[1]:I vcodiv_ratio[0]:I vctlrdacctlnh[3]:I vctlrdacctlnh[2]:I vctlrdacctlnh[1]:I vctlrdacctlnh[0]:I vctlrdacennl:I
* .PININFO viewanaennh[1]:I viewanaennh[0]:I viewdigennh[1]:I viewdigennh[0]:I viewsel0[4]:I viewsel0[3]:I viewsel0[2]:I viewsel0[1]:I viewsel0[0]:I
* .PININFO viewsel1[4]:I viewsel1[3]:I viewsel1[2]:I viewsel1[1]:I viewsel1[0]:I vssx:I zdiv0ratiop5:I zdiv1ratiop5:I adc_dig_out[9]:O
* .PININFO adc_dig_out[8]:O adc_dig_out[7]:O adc_dig_out[6]:O adc_dig_out[5]:O adc_dig_out[4]:O adc_dig_out[3]:O adc_dig_out[2]:O adc_dig_out[1]:O
* .PININFO adc_dig_out[0]:O adc_done:O clkfbmxh:O clkidvih:O clkplldiv0:O clkplldiv1:O clkpllmh:O pfdlockrstnh:O viewanabusnh[1]:O viewanabusnh[0]:O
* .PININFO viewoutnh[1]:O viewoutnh[0]:O
Xiviewmux viewout_pre[1] viewout_pre[0] clkfb clkpostdistmh_ls2 clkrefxxh_ls2 clkref_div earlylock_ls lock_ls mod_clk_to_view_ls pfden pll_core_clk_buf1 net142 powergood_ls rawlock_ls reset_b_ls ssc_reload_ls vccpll vctlrdacennl_ls viewdigen_ls[1] viewdigen_ls[0] viewsel0_ls[4] viewsel0_ls[3] viewsel0_ls[2] viewsel0_ls[1] viewsel0_ls[0] viewsel1_ls[4] viewsel1_ls[3] viewsel1_ls[2] viewsel1_ls[1] viewsel1_ls[0] vssx ringpll__pll_viewmux
Xiidvgate clkidv_pre clkfb2 idv_gate_en_ls vccpll vssx ringpll__pll_idvgate
Xidca pll_core_clkm fz_dca_cb_ls[1] fz_dca_cb_ls[0] pll_core_clk fz_dca_ctrl_ls[5] fz_dca_ctrl_ls[4] fz_dca_ctrl_ls[3] fz_dca_ctrl_ls[2] fz_dca_ctrl_ls[1] fz_dca_ctrl_ls[0] vccpll vssx ringpll__pll_dca2
Xi273[1] viewoutnh[1] resetb_vccdig viewout_preb[1] vccpll vccdig vssx ringpll__pll_lsout_clk2
Xi273[0] viewoutnh[0] resetb_vccdig viewout_preb[0] vccpll vccdig vssx ringpll__pll_lsout_clk2
Xi279 clkpllmh resetb_vccdist clkpll_preb vccpll vccdist vssx ringpll__pll_lsout_clk2
Xidecap[1] vccpll vssx ringpll__pdecap_s2p_pcell_54
Xidecap[0] vccpll vssx ringpll__pdecap_s2p_pcell_54
Xipostdiv0 clkplldiv0 gt10 clkpllmh vssx ratiozdiv0_ls[9] ratiozdiv0_ls[8] ratiozdiv0_ls[7] ratiozdiv0_ls[6] ratiozdiv0_ls[5] ratiozdiv0_ls[4] ratiozdiv0_ls[3] ratiozdiv0_ls[2] ratiozdiv0_ls[1] ratiozdiv0_ls[0] zdiv0ratiop5_ls vccdist vssx resetb_vccdist ringpll__pll_clkdiv_syncrst_div0
Xi280 resetb_vccdist reset_b_dly vccdig vccdist vssx ringpll__pll_lsin
Xi249 ssc_reload_ls ssc_reload vccdig vccpll vssx ringpll__pll_lsin
Xi248 earlylock_ls earlylockxxh vccdig vccpll vssx ringpll__pll_lsin
Xi197[4] fz_irefgen_ls[4] fz_irefgen[4] vccdig vccpll vssx ringpll__pll_lsin
Xi197[3] fz_irefgen_ls[3] fz_irefgen[3] vccdig vccpll vssx ringpll__pll_lsin
Xi197[2] fz_irefgen_ls[2] fz_irefgen[2] vccdig vccpll vssx ringpll__pll_lsin
Xi197[1] fz_irefgen_ls[1] fz_irefgen[1] vccdig vccpll vssx ringpll__pll_lsin
Xi197[0] fz_irefgen_ls[0] fz_irefgen[0] vccdig vccpll vssx ringpll__pll_lsin
Xi219 idv_gate_en_ls idv_gate_en vccdig vccpll vssx ringpll__pll_lsin
Xi212 reset_b_ls reset_b_dly vccdig vccpll vssx ringpll__pll_lsin
Xi211 pfden pfdennh vccdig vccpll vssx ringpll__pll_lsin
Xi178[5] mdiv_ratio_ls[5] mdiv_ratio[5] vccdig vccpll vssx ringpll__pll_lsin
Xi178[4] mdiv_ratio_ls[4] mdiv_ratio[4] vccdig vccpll vssx ringpll__pll_lsin
Xi178[3] mdiv_ratio_ls[3] mdiv_ratio[3] vccdig vccpll vssx ringpll__pll_lsin
Xi178[2] mdiv_ratio_ls[2] mdiv_ratio[2] vccdig vccpll vssx ringpll__pll_lsin
Xi178[1] mdiv_ratio_ls[1] mdiv_ratio[1] vccdig vccpll vssx ringpll__pll_lsin
Xi178[0] mdiv_ratio_ls[0] mdiv_ratio[0] vccdig vccpll vssx ringpll__pll_lsin
Xi204[3] vctlrdac_ls[3] vctlrdacctlnh[3] vccdig vccpll vssx ringpll__pll_lsin
Xi204[2] vctlrdac_ls[2] vctlrdacctlnh[2] vccdig vccpll vssx ringpll__pll_lsin
Xi204[1] vctlrdac_ls[1] vctlrdacctlnh[1] vccdig vccpll vssx ringpll__pll_lsin
Xi204[0] vctlrdac_ls[0] vctlrdacctlnh[0] vccdig vccpll vssx ringpll__pll_lsin
Xi207 vctlrdacennl_ls vctlrdacennl vccdig vccpll vssx ringpll__pll_lsin
Xi200[2] fz_pfd_pw_ls[2] fz_pfd_pw[2] vccdig vccpll vssx ringpll__pll_lsin
Xi200[1] fz_pfd_pw_ls[1] fz_pfd_pw[1] vccdig vccpll vssx ringpll__pll_lsin
Xi200[0] fz_pfd_pw_ls[0] fz_pfd_pw[0] vccdig vccpll vssx ringpll__pll_lsin
Xi247 rawlock_ls rawlockxxl vccdig vccpll vssx ringpll__pll_lsin
Xi209[4] fz_skadj_ls[4] fz_skadj[4] vccdig vccpll vssx ringpll__pll_lsin
Xi209[3] fz_skadj_ls[3] fz_skadj[3] vccdig vccpll vssx ringpll__pll_lsin
Xi209[2] fz_skadj_ls[2] fz_skadj[2] vccdig vccpll vssx ringpll__pll_lsin
Xi209[1] fz_skadj_ls[1] fz_skadj[1] vccdig vccpll vssx ringpll__pll_lsin
Xi209[0] fz_skadj_ls[0] fz_skadj[0] vccdig vccpll vssx ringpll__pll_lsin
Xi205[1] pdivrat[1] vcodiv_ratio[1] vccdig vccpll vssx ringpll__pll_lsin
Xi205[0] pdivrat[0] vcodiv_ratio[0] vccdig vccpll vssx ringpll__pll_lsin
Xi208[10] fz_vcotrim_ls[10] fz_vcotrim[10] vccdig vccpll vssx ringpll__pll_lsin
Xi208[9] fz_vcotrim_ls[9] fz_vcotrim[9] vccdig vccpll vssx ringpll__pll_lsin
Xi208[8] fz_vcotrim_ls[8] fz_vcotrim[8] vccdig vccpll vssx ringpll__pll_lsin
Xi208[7] fz_vcotrim_ls[7] fz_vcotrim[7] vccdig vccpll vssx ringpll__pll_lsin
Xi208[6] fz_vcotrim_ls[6] fz_vcotrim[6] vccdig vccpll vssx ringpll__pll_lsin
Xi208[5] fz_vcotrim_ls[5] fz_vcotrim[5] vccdig vccpll vssx ringpll__pll_lsin
Xi208[4] fz_vcotrim_ls[4] fz_vcotrim[4] vccdig vccpll vssx ringpll__pll_lsin
Xi208[3] fz_vcotrim_ls[3] fz_vcotrim[3] vccdig vccpll vssx ringpll__pll_lsin
Xi208[2] fz_vcotrim_ls[2] fz_vcotrim[2] vccdig vccpll vssx ringpll__pll_lsin
Xi208[1] fz_vcotrim_ls[1] fz_vcotrim[1] vccdig vccpll vssx ringpll__pll_lsin
Xi208[0] fz_vcotrim_ls[0] fz_vcotrim[0] vccdig vccpll vssx ringpll__pll_lsin
Xi214[2] adc_sel_in_ls[2] adc_sel_in[2] vccdig vccpll vssx ringpll__pll_lsin
Xi214[1] adc_sel_in_ls[1] adc_sel_in[1] vccdig vccpll vssx ringpll__pll_lsin
Xi214[0] adc_sel_in_ls[0] adc_sel_in[0] vccdig vccpll vssx ringpll__pll_lsin
Xi246 lock_ls lockxxl vccdig vccpll vssx ringpll__pll_lsin
Xi206 rdactovclen_ls rdactovctlennh vccdig vccpll vssx ringpll__pll_lsin
Xi196[4] fz_cp2trim_ls[4] fz_cp2trim[4] vccdig vccpll vssx ringpll__pll_lsin
Xi196[3] fz_cp2trim_ls[3] fz_cp2trim[3] vccdig vccpll vssx ringpll__pll_lsin
Xi196[2] fz_cp2trim_ls[2] fz_cp2trim[2] vccdig vccpll vssx ringpll__pll_lsin
Xi196[1] fz_cp2trim_ls[1] fz_cp2trim[1] vccdig vccpll vssx ringpll__pll_lsin
Xi196[0] fz_cp2trim_ls[0] fz_cp2trim[0] vccdig vccpll vssx ringpll__pll_lsin
Xi202 fz_nopfdpwrate_ls fz_nopfdpwrgate vccdig vccpll vssx ringpll__pll_lsin
Xi203[5] fz_startup_ls[5] fz_startup[5] vccdig vccpll vssx ringpll__pll_lsin
Xi203[4] fz_startup_ls[4] fz_startup[4] vccdig vccpll vssx ringpll__pll_lsin
Xi203[3] fz_startup_ls[3] fz_startup[3] vccdig vccpll vssx ringpll__pll_lsin
Xi203[2] fz_startup_ls[2] fz_startup[2] vccdig vccpll vssx ringpll__pll_lsin
Xi203[1] fz_startup_ls[1] fz_startup[1] vccdig vccpll vssx ringpll__pll_lsin
Xi203[0] fz_startup_ls[0] fz_startup[0] vccdig vccpll vssx ringpll__pll_lsin
Xi201[1] fz_pfddly_ls[1] fz_pfddly[1] vccdig vccpll vssx ringpll__pll_lsin
Xi228 adc_chop_en_ls adc_chop_en vccdig vccpll vssx ringpll__pll_lsin
Xi234[4] ta_spare_ls[4] ta_spare[4] vccdig vccpll vssx ringpll__pll_lsin
Xi234[3] ta_spare_ls[3] ta_spare[3] vccdig vccpll vssx ringpll__pll_lsin
Xi234[2] ta_spare_ls[2] ta_spare[2] vccdig vccpll vssx ringpll__pll_lsin
Xi234[1] ta_spare_ls[1] ta_spare[1] vccdig vccpll vssx ringpll__pll_lsin
Xi234[0] ta_spare_ls[0] ta_spare[0] vccdig vccpll vssx ringpll__pll_lsin
Xi230 adc_freeze_ls adc_freeze vccdig vccpll vssx ringpll__pll_lsin
Xi231 adc_reset_bxxl_ls adc_reset_bxxl vccdig vccpll vssx ringpll__pll_lsin
Xi232 adc_startxxh_ls adc_startxxh vccdig vccpll vssx ringpll__pll_lsin
Xi233 adc_use_vref_ls adc_use_vref vccdig vccpll vssx ringpll__pll_lsin
Xi199[3] fz_lockthresh_ls[3] fz_lockthresh[3] vccdig vccpll vssx ringpll__pll_lsin
Xi199[2] fz_lockthresh_ls[2] fz_lockthresh[2] vccdig vccpll vssx ringpll__pll_lsin
Xi199[1] fz_lockthresh_ls[1] fz_lockthresh[1] vccdig vccpll vssx ringpll__pll_lsin
Xi199[0] fz_lockthresh_ls[0] fz_lockthresh[0] vccdig vccpll vssx ringpll__pll_lsin
Xi243[1] viewdigen_ls[1] viewdigennh[1] vccdig vccpll vssx ringpll__pll_lsin
Xi243[0] viewdigen_ls[0] viewdigennh[0] vccdig vccpll vssx ringpll__pll_lsin
Xi245[4] viewsel1_ls[4] viewsel1[4] vccdig vccpll vssx ringpll__pll_lsin
Xi245[3] viewsel1_ls[3] viewsel1[3] vccdig vccpll vssx ringpll__pll_lsin
Xi245[2] viewsel1_ls[2] viewsel1[2] vccdig vccpll vssx ringpll__pll_lsin
Xi245[1] viewsel1_ls[1] viewsel1[1] vccdig vccpll vssx ringpll__pll_lsin
Xi245[0] viewsel1_ls[0] viewsel1[0] vccdig vccpll vssx ringpll__pll_lsin
Xi242 powergood_ls powergood vccdig vccpll vssx ringpll__pll_lsin
Xi244[4] viewsel0_ls[4] viewsel0[4] vccdig vccpll vssx ringpll__pll_lsin
Xi244[3] viewsel0_ls[3] viewsel0[3] vccdig vccpll vssx ringpll__pll_lsin
Xi244[2] viewsel0_ls[2] viewsel0[2] vccdig vccpll vssx ringpll__pll_lsin
Xi244[1] viewsel0_ls[1] viewsel0[1] vccdig vccpll vssx ringpll__pll_lsin
Xi244[0] viewsel0_ls[0] viewsel0[0] vccdig vccpll vssx ringpll__pll_lsin
Xi167[9] ratiozdiv0_ls[9] ratiozdiv0[9] vccdig vccdist vssx ringpll__pll_lsin
Xi167[8] ratiozdiv0_ls[8] ratiozdiv0[8] vccdig vccdist vssx ringpll__pll_lsin
Xi167[7] ratiozdiv0_ls[7] ratiozdiv0[7] vccdig vccdist vssx ringpll__pll_lsin
Xi167[6] ratiozdiv0_ls[6] ratiozdiv0[6] vccdig vccdist vssx ringpll__pll_lsin
Xi167[5] ratiozdiv0_ls[5] ratiozdiv0[5] vccdig vccdist vssx ringpll__pll_lsin
Xi167[4] ratiozdiv0_ls[4] ratiozdiv0[4] vccdig vccdist vssx ringpll__pll_lsin
Xi167[3] ratiozdiv0_ls[3] ratiozdiv0[3] vccdig vccdist vssx ringpll__pll_lsin
Xi167[2] ratiozdiv0_ls[2] ratiozdiv0[2] vccdig vccdist vssx ringpll__pll_lsin
Xi167[1] ratiozdiv0_ls[1] ratiozdiv0[1] vccdig vccdist vssx ringpll__pll_lsin
Xi167[0] ratiozdiv0_ls[0] ratiozdiv0[0] vccdig vccdist vssx ringpll__pll_lsin
Xi176 zdiv1ratiop5_ls zdiv1ratiop5 vccdig vccdist vssx ringpll__pll_lsin
Xi172 zdiv0ratiop5_ls zdiv0ratiop5 vccdig vccdist vssx ringpll__pll_lsin
Xi175[5] fz_dca_ctrl_ls[5] fz_dca_ctrl[5] vccdig vccpll vssx ringpll__pll_lsin
Xi175[4] fz_dca_ctrl_ls[4] fz_dca_ctrl[4] vccdig vccpll vssx ringpll__pll_lsin
Xi175[3] fz_dca_ctrl_ls[3] fz_dca_ctrl[3] vccdig vccpll vssx ringpll__pll_lsin
Xi175[2] fz_dca_ctrl_ls[2] fz_dca_ctrl[2] vccdig vccpll vssx ringpll__pll_lsin
Xi175[1] fz_dca_ctrl_ls[1] fz_dca_ctrl[1] vccdig vccpll vssx ringpll__pll_lsin
Xi175[0] fz_dca_ctrl_ls[0] fz_dca_ctrl[0] vccdig vccpll vssx ringpll__pll_lsin
Xi174[1] fz_dca_cb_ls[1] fz_dca_cb[1] vccdig vccpll vssx ringpll__pll_lsin
Xi174[0] fz_dca_cb_ls[0] fz_dca_cb[0] vccdig vccpll vssx ringpll__pll_lsin
Xi225 net154 tllm_gate_clk_trunk vccdig vccpll vssx ringpll__pll_lsin
Xi224 tllm_force_tight_loop_ls tllm_force_tight_loop vccdig vccpll vssx ringpll__pll_lsin
Xi216 bypass_ls bypassxxl vccdig vccpll vssx ringpll__pll_lsin
Xi215 reset_b_ls_early rb_and_pwrgood_sync_buf vccdig vccpll vssx ringpll__pll_lsin
Xi251 mod_clk_to_view_ls mod_clk_to_view vccdig vccpll vssx ringpll__pll_lsin
Xi226 nclpfclksel fz_lpfclksel vccdig vccpll vssx ringpll__pll_lsin
Xi221 ratio_halfint_ls ratio_halfint vccdig vccpll vssx ringpll__pll_lsin
Xi195[4] fz_cp1trim_ls[4] fz_cp1trim[4] vccdig vccpll vssx ringpll__pll_lsin
Xi195[3] fz_cp1trim_ls[3] fz_cp1trim[3] vccdig vccpll vssx ringpll__pll_lsin
Xi195[2] fz_cp1trim_ls[2] fz_cp1trim[2] vccdig vccpll vssx ringpll__pll_lsin
Xi195[1] fz_cp1trim_ls[1] fz_cp1trim[1] vccdig vccpll vssx ringpll__pll_lsin
Xi195[0] fz_cp1trim_ls[0] fz_cp1trim[0] vccdig vccpll vssx ringpll__pll_lsin
Xi227[4] fz_spare_ls[4] fz_spare[4] vccdig vccpll vssx ringpll__pll_lsin
Xi227[3] fz_spare_ls[3] fz_spare[3] vccdig vccpll vssx ringpll__pll_lsin
Xi227[2] fz_spare_ls[2] fz_spare[2] vccdig vccpll vssx ringpll__pll_lsin
Xi227[1] fz_spare_ls[1] fz_spare[1] vccdig vccpll vssx ringpll__pll_lsin
Xi227[0] fz_spare_ls[0] fz_spare[0] vccdig vccpll vssx ringpll__pll_lsin
Xi173[9] ratiozdiv1_ls[9] ratiozdiv1[9] vccdig vccdist vssx ringpll__pll_lsin
Xi173[8] ratiozdiv1_ls[8] ratiozdiv1[8] vccdig vccdist vssx ringpll__pll_lsin
Xi173[7] ratiozdiv1_ls[7] ratiozdiv1[7] vccdig vccdist vssx ringpll__pll_lsin
Xi173[6] ratiozdiv1_ls[6] ratiozdiv1[6] vccdig vccdist vssx ringpll__pll_lsin
Xi173[5] ratiozdiv1_ls[5] ratiozdiv1[5] vccdig vccdist vssx ringpll__pll_lsin
Xi173[4] ratiozdiv1_ls[4] ratiozdiv1[4] vccdig vccdist vssx ringpll__pll_lsin
Xi173[3] ratiozdiv1_ls[3] ratiozdiv1[3] vccdig vccdist vssx ringpll__pll_lsin
Xi173[2] ratiozdiv1_ls[2] ratiozdiv1[2] vccdig vccdist vssx ringpll__pll_lsin
Xi173[1] ratiozdiv1_ls[1] ratiozdiv1[1] vccdig vccdist vssx ringpll__pll_lsin
Xi173[0] ratiozdiv1_ls[0] ratiozdiv1[0] vccdig vccdist vssx ringpll__pll_lsin
Xi210 fz_vcosel_ls fz_vcosel vccdig vccpll vssx ringpll__pll_lsin
Xi220[9] ratio_ls[9] ratio[9] vccdig vccpll vssx ringpll__pll_lsin
Xi220[8] ratio_ls[8] ratio[8] vccdig vccpll vssx ringpll__pll_lsin
Xi220[7] ratio_ls[7] ratio[7] vccdig vccpll vssx ringpll__pll_lsin
Xi220[6] ratio_ls[6] ratio[6] vccdig vccpll vssx ringpll__pll_lsin
Xi220[5] ratio_ls[5] ratio[5] vccdig vccpll vssx ringpll__pll_lsin
Xi220[4] ratio_ls[4] ratio[4] vccdig vccpll vssx ringpll__pll_lsin
Xi220[3] ratio_ls[3] ratio[3] vccdig vccpll vssx ringpll__pll_lsin
Xi220[2] ratio_ls[2] ratio[2] vccdig vccpll vssx ringpll__pll_lsin
Xi220[1] ratio_ls[1] ratio[1] vccdig vccpll vssx ringpll__pll_lsin
Xi220[0] ratio_ls[0] ratio[0] vccdig vccpll vssx ringpll__pll_lsin
Xi229[1] adc_clkdiv_ls[1] adc_clkdiv[1] vccdig vccpll vssx ringpll__pll_lsin
Xi229[0] adc_clkdiv_ls[0] adc_clkdiv[0] vccdig vccpll vssx ringpll__pll_lsin
Xi271[9] adc_dig_out[9] reset_vccdig adc_dig_out_pre[9] vccpll vccdig vssx ringpll__pll_lsout
Xi271[8] adc_dig_out[8] reset_vccdig adc_dig_out_pre[8] vccpll vccdig vssx ringpll__pll_lsout
Xi271[7] adc_dig_out[7] reset_vccdig adc_dig_out_pre[7] vccpll vccdig vssx ringpll__pll_lsout
Xi271[6] adc_dig_out[6] reset_vccdig adc_dig_out_pre[6] vccpll vccdig vssx ringpll__pll_lsout
Xi271[5] adc_dig_out[5] reset_vccdig adc_dig_out_pre[5] vccpll vccdig vssx ringpll__pll_lsout
Xi271[4] adc_dig_out[4] reset_vccdig adc_dig_out_pre[4] vccpll vccdig vssx ringpll__pll_lsout
Xi271[3] adc_dig_out[3] reset_vccdig adc_dig_out_pre[3] vccpll vccdig vssx ringpll__pll_lsout
Xi271[2] adc_dig_out[2] reset_vccdig adc_dig_out_pre[2] vccpll vccdig vssx ringpll__pll_lsout
Xi271[1] adc_dig_out[1] reset_vccdig adc_dig_out_pre[1] vccpll vccdig vssx ringpll__pll_lsout
Xi271[0] adc_dig_out[0] reset_vccdig adc_dig_out_pre[0] vccpll vccdig vssx ringpll__pll_lsout
Xi272 adc_done reset_vccdig adc_done_pre vccpll vccdig vssx ringpll__pll_lsout
Xi270 clkfbmxh reset_vccdig clkfb2 vccpll vccdig vssx ringpll__pll_lsout
Xi269 clkidvih reset_vccdig clkidv_pre vccpll vccdig vssx ringpll__pll_lsout
Xi267 pfdlockrstnh reset_vccdig lockrst vccpll vccdig vssx ringpll__pll_lsout
Xigmux pll_core_clkd bypass_ls reset_b_ls_early pll_core_clkm reset_b_ls clkrefxxh_ls2 vccpll vssx ringpll__pll_glitchlessmux
Xi201[0] fz_pfddly_ls[0] fz_pfddly[0] vccdig vccpll vssx ringpll__pll_lsin_bar
Xi198[1] fz_cpnbias_ls[1] fz_cpnbias[1] vccdig vccpll vssx ringpll__pll_lsin_bar
Xi198[0] fz_cpnbias_ls[0] fz_cpnbias[0] vccdig vccpll vssx ringpll__pll_lsin_bar
Xi223 fz_tight_loop fz_tight_loopb vccdig vccpll vssx ringpll__pll_lsin_bar
Xi281 reset_vccdig rb_and_pwrgood_sync_buf vccdig vssx ringpll__pll_nolsin_bar
Xi266 clkpostdistmh_ls clkpostdistmh_ls2 clkpostdistmh vccdist vccpll vssx ringpll__pll_lsin_clk
Xi177 clkrefxxh_ls clkrefxxh_ls2 clkrefxxh vccdig vccpll vssx ringpll__pll_lsin_clk
Xirstdly reset_b_dly rb_and_pwrgood_sync_buf vccdig vssx ringpll__pll_rstdly
Xiviewadc adc_dig_out_pre[9] adc_dig_out_pre[8] adc_dig_out_pre[7] adc_dig_out_pre[6] adc_dig_out_pre[5] adc_dig_out_pre[4] adc_dig_out_pre[3] adc_dig_out_pre[2] adc_dig_out_pre[1] adc_dig_out_pre[0] adc_done_pre adc_chop_en_ls adc_clkdiv_ls[1] adc_clkdiv_ls[0] adc_freeze_ls adc_reset_bxxl_ls adc_startxxh_ls clkrefxxh_ls2 pll_core_adc_in vccpll vccpll vssx ringpll__pll_viewadc2
Xfmy20 clkrefxxh powergood rb_and_pwrgood_sync reset_b_xxl vccdig vccdig vccdig vssx ringpll__b15fmy203al1n04x5 m=1
Xinv00 reset_vccdig resetb_vccdig vccdig vssx ringpll__b15inv000al1n04x5 m=1
Xiana pll_core_adc_in pll_core_clk lockrst viewanabusnh[1] viewanabusnh[0] adc_sel_in_ls[2] adc_sel_in_ls[1] adc_sel_in_ls[0] anadft_ldo anadft_ldovfb anadft_ldovref clkfb clkref_div fz_cp1trim_ls[4] fz_cp1trim_ls[3] fz_cp1trim_ls[2] fz_cp1trim_ls[1] fz_cp1trim_ls[0] fz_cp2trim_ls[4] fz_cp2trim_ls[3] fz_cp2trim_ls[2] fz_cp2trim_ls[1] fz_cp2trim_ls[0] fz_cpnbias_ls[1] fz_cpnbias_ls[0] fz_irefgen_ls[4] fz_irefgen_ls[3] fz_irefgen_ls[2] fz_irefgen_ls[1] fz_irefgen_ls[0] fz_lockthresh_ls[3] fz_lockthresh_ls[2] fz_lockthresh_ls[1] fz_lockthresh_ls[0] fz_nopfdpwrate_ls fz_pfd_pw_ls[2] fz_pfd_pw_ls[1] fz_pfd_pw_ls[0] fz_pfddly_ls[1] fz_pfddly_ls[0] fz_skadj_ls[4] fz_skadj_ls[3] fz_skadj_ls[2] fz_skadj_ls[1] fz_skadj_ls[0] fz_startup_ls[5] fz_startup_ls[4] fz_startup_ls[3] fz_startup_ls[2] fz_startup_ls[1] fz_startup_ls[0] fz_vcosel_ls fz_vcotrim_ls[10] fz_vcotrim_ls[9] fz_vcotrim_ls[8] fz_vcotrim_ls[7] fz_vcotrim_ls[6] fz_vcotrim_ls[5] fz_vcotrim_ls[4] fz_vcotrim_ls[3] fz_vcotrim_ls[2] fz_vcotrim_ls[1] fz_vcotrim_ls[0] pdivrat[1] pdivrat[0] pfden rdactovclen_ls reset_b_ls vccdig vccpll vccvdd2 vctlrdac_ls[3] vctlrdac_ls[2] vctlrdac_ls[1] vctlrdac_ls[0] vctlrdacennl_ls viewanaennh[1] viewanaennh[0] vssx ringpll__pll_ana
Xifbdiv clkfb clkfb2 net142 pll_core_clk_buf1 clkpostdistmh_ls idv_gate_en_ls pfden ratio_ls[9] ratio_ls[8] ratio_ls[7] ratio_ls[6] ratio_ls[5] ratio_ls[4] ratio_ls[3] ratio_ls[2] ratio_ls[1] ratio_ls[0] ratio_halfint_ls reset_b_ls fz_tight_loop gate_gridclkb tlctrl_tight_loopb vccpll vssx ringpll__pll_fbgen_b0
Xcinv0 pll_core_clkd clkpll_preb vccpll vssx ringpll__b15cinv00ah1n06x5 m=1
Xcinv1[1] viewout_pre[1] viewout_preb[1] vccpll vssx ringpll__b15cinv00ah1n06x5 m=1
Xcinv1[0] viewout_pre[0] viewout_preb[0] vccpll vssx ringpll__b15cinv00ah1n06x5 m=1
Xand00 reset_b_xxl powergood rb_and_pwrgood vccdig vssx ringpll__b15and002al1n16x5 m=1
Xipostdiv1 clkplldiv1 gt11 clkpllmh vssx ratiozdiv1_ls[9] ratiozdiv1_ls[8] ratiozdiv1_ls[7] ratiozdiv1_ls[6] ratiozdiv1_ls[5] ratiozdiv1_ls[4] ratiozdiv1_ls[3] ratiozdiv1_ls[2] ratiozdiv1_ls[1] ratiozdiv1_ls[0] zdiv1ratiop5_ls resetb_vccdist vccdist vssx ringpll__pll_clkdiv_syncrst_div1
Xitlctrl gate_gridclkb tlctrl_tight_loopb pll_core_clk_buf1 clkpostdistmh_ls2 fz_tight_loop reset_b_ls tllm_force_tight_loop_ls vccpll vssx ringpll__pll_tlctrl_hip
Xcbf00 pll_core_clk pll_core_clk_buf1 vccpll vssx ringpll__b15cbf000ah1n12x5 m=1
Xbfm40 rb_and_pwrgood_sync rb_and_pwrgood_sync_buf vccdig vssx ringpll__b15bfm402al1n16x5 m=1
Xirefdiv clkref_div clkrefxxh_ls mdiv_ratio_ls[5] mdiv_ratio_ls[4] mdiv_ratio_ls[3] mdiv_ratio_ls[2] mdiv_ratio_ls[1] mdiv_ratio_ls[0] reset_b_ls fz_tight_loop vccpll vssx ringpll__pll_refdiv2
.ENDS

* ***********************************************************************
*  Library Name: ip2229appgrngplllib_ihdk_sch
*  Cell Name:    ringpll
*  View Name:    schematic
* ***********************************************************************
.SUBCKT ringpll clkpll clkpll0 clkpll1 idvdisable_bo idvfreqao idvfreqbo idvpulseo idvtclko idvtctrlo idvtdo idvtreso lock odfx_fscan_sdo[2] odfx_fscan_sdo[1] odfx_fscan_sdo[0] tdo view_dig_out[1] view_dig_out[0] viewanabus[1] viewanabus[0] bypass clkpostdist clkref fraction[23] fraction[22] fraction[21] fraction[20] fraction[19] fraction[18] fraction[17] fraction[16] fraction[15] fraction[14] fraction[13] fraction[12] fraction[11] fraction[10] fraction[9] fraction[8] fraction[7] fraction[6] fraction[5] fraction[4] fraction[3] fraction[2] fraction[1] fraction[0] fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] fz_cpnbias[1] fz_cpnbias[0] fz_dca_cb[1] fz_dca_cb[0] fz_dca_ctrl[5] fz_dca_ctrl[4] fz_dca_ctrl[3] fz_dca_ctrl[2] fz_dca_ctrl[1] fz_dca_ctrl[0] fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] fz_ldo_bypass fz_ldo_extrefsel fz_ldo_faststart fz_ldo_fbtrim[3] fz_ldo_fbtrim[2] fz_ldo_fbtrim[1] fz_ldo_fbtrim[0] fz_ldo_reftrim[3] fz_ldo_reftrim[2] fz_ldo_reftrim[1] fz_ldo_reftrim[0] fz_ldo_vinvoltsel[1] fz_ldo_vinvoltsel[0] fz_lockcnt[2] fz_lockcnt[1] fz_lockcnt[0] fz_lockforce fz_lockstickyb fz_lockthresh[3] fz_lockthresh[2] fz_lockthresh[1] fz_lockthresh[0] fz_lpfclksel fz_nopfdpwrgate fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] fz_pfddly[1] fz_pfddly[0] fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] fz_spare[4] fz_spare[3] fz_spare[2] fz_spare[1] fz_spare[0] fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] fz_tight_loopb fz_vcosel fz_vcotrim[10] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] idfx_fscan_byprstb idfx_fscan_clkungate idfx_fscan_mode idfx_fscan_rstbypen idfx_fscan_sdi[2] idfx_fscan_sdi[1] idfx_fscan_sdi[0] idfx_fscan_shiften idvdisable_bi idvfreqai idvfreqbi idvpulsei idvtclki idvtctrli idvtdi idvtresi ldo_enable ldo_vref mash_order_plus_one mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] pllen pllfwen_b powergood_vnn ratio[9] ratio[8] ratio[7] ratio[6] ratio[5] ratio[4] ratio[3] ratio[2] ratio[1] ratio[0] ssc_cyc_to_peak_m1[8] ssc_cyc_to_peak_m1[7] ssc_cyc_to_peak_m1[6] ssc_cyc_to_peak_m1[5] ssc_cyc_to_peak_m1[4] ssc_cyc_to_peak_m1[3] ssc_cyc_to_peak_m1[2] ssc_cyc_to_peak_m1[1] ssc_cyc_to_peak_m1[0] ssc_en ssc_frac_step[23] ssc_frac_step[22] ssc_frac_step[21] ssc_frac_step[20] ssc_frac_step[19] ssc_frac_step[18] ssc_frac_step[17] ssc_frac_step[16] ssc_frac_step[15] ssc_frac_step[14] ssc_frac_step[13] ssc_frac_step[12] ssc_frac_step[11] ssc_frac_step[10] ssc_frac_step[9] ssc_frac_step[8] ssc_frac_step[7] ssc_frac_step[6] ssc_frac_step[5] ssc_frac_step[4] ssc_frac_step[3] ssc_frac_step[2] ssc_frac_step[1] ssc_frac_step[0] tcapturedr tck tdi treg_en trst_n tshiftdr tupdatedr vccdig_nom vccdist_nom vccldo_hv vcodiv_ratio[1] vcodiv_ratio[0] vnnaon_nom vss zdiv0_ratio[9] zdiv0_ratio[8] zdiv0_ratio[7] zdiv0_ratio[6] zdiv0_ratio[5] zdiv0_ratio[4] zdiv0_ratio[3] zdiv0_ratio[2] zdiv0_ratio[1] zdiv0_ratio[0] zdiv0_ratio_p5 zdiv1_ratio[9] zdiv1_ratio[8] zdiv1_ratio[7] zdiv1_ratio[6] zdiv1_ratio[5] zdiv1_ratio[4] zdiv1_ratio[3] zdiv1_ratio[2] zdiv1_ratio[1] zdiv1_ratio[0] zdiv1_ratio_p5
* .PININFO bypass:I clkpostdist:I clkref:I fraction[23]:I fraction[22]:I fraction[21]:I fraction[20]:I fraction[19]:I fraction[18]:I fraction[17]:I
* .PININFO fraction[16]:I fraction[15]:I fraction[14]:I fraction[13]:I fraction[12]:I fraction[11]:I fraction[10]:I fraction[9]:I fraction[8]:I
* .PININFO fraction[7]:I fraction[6]:I fraction[5]:I fraction[4]:I fraction[3]:I fraction[2]:I fraction[1]:I fraction[0]:I fz_cp1trim[4]:I
* .PININFO fz_cp1trim[3]:I fz_cp1trim[2]:I fz_cp1trim[1]:I fz_cp1trim[0]:I fz_cp2trim[4]:I fz_cp2trim[3]:I fz_cp2trim[2]:I fz_cp2trim[1]:I
* .PININFO fz_cp2trim[0]:I fz_cpnbias[1]:I fz_cpnbias[0]:I fz_dca_cb[1]:I fz_dca_cb[0]:I fz_dca_ctrl[5]:I fz_dca_ctrl[4]:I fz_dca_ctrl[3]:I
* .PININFO fz_dca_ctrl[2]:I fz_dca_ctrl[1]:I fz_dca_ctrl[0]:I fz_irefgen[4]:I fz_irefgen[3]:I fz_irefgen[2]:I fz_irefgen[1]:I fz_irefgen[0]:I
* .PININFO fz_ldo_bypass:I fz_ldo_extrefsel:I fz_ldo_faststart:I fz_ldo_fbtrim[3]:I fz_ldo_fbtrim[2]:I fz_ldo_fbtrim[1]:I fz_ldo_fbtrim[0]:I
* .PININFO fz_ldo_reftrim[3]:I fz_ldo_reftrim[2]:I fz_ldo_reftrim[1]:I fz_ldo_reftrim[0]:I fz_ldo_vinvoltsel[1]:I fz_ldo_vinvoltsel[0]:I
* .PININFO fz_lockcnt[2]:I fz_lockcnt[1]:I fz_lockcnt[0]:I fz_lockforce:I fz_lockstickyb:I fz_lockthresh[3]:I fz_lockthresh[2]:I fz_lockthresh[1]:I
* .PININFO fz_lockthresh[0]:I fz_lpfclksel:I fz_nopfdpwrgate:I fz_pfd_pw[2]:I fz_pfd_pw[1]:I fz_pfd_pw[0]:I fz_pfddly[1]:I fz_pfddly[0]:I
* .PININFO fz_skadj[4]:I fz_skadj[3]:I fz_skadj[2]:I fz_skadj[1]:I fz_skadj[0]:I fz_spare[4]:I fz_spare[3]:I fz_spare[2]:I fz_spare[1]:I fz_spare[0]:I
* .PININFO fz_startup[5]:I fz_startup[4]:I fz_startup[3]:I fz_startup[2]:I fz_startup[1]:I fz_startup[0]:I fz_tight_loopb:I fz_vcosel:I
* .PININFO fz_vcotrim[10]:I fz_vcotrim[9]:I fz_vcotrim[8]:I fz_vcotrim[7]:I fz_vcotrim[6]:I fz_vcotrim[5]:I fz_vcotrim[4]:I fz_vcotrim[3]:I
* .PININFO fz_vcotrim[2]:I fz_vcotrim[1]:I fz_vcotrim[0]:I idfx_fscan_byprstb:I idfx_fscan_clkungate:I idfx_fscan_mode:I idfx_fscan_rstbypen:I
* .PININFO idfx_fscan_sdi[2]:I idfx_fscan_sdi[1]:I idfx_fscan_sdi[0]:I idfx_fscan_shiften:I idvdisable_bi:I idvfreqai:I idvfreqbi:I idvpulsei:I
* .PININFO idvtclki:I idvtctrli:I idvtdi:I idvtresi:I ldo_enable:I ldo_vref:I mash_order_plus_one:I mdiv_ratio[5]:I mdiv_ratio[4]:I mdiv_ratio[3]:I
* .PININFO mdiv_ratio[2]:I mdiv_ratio[1]:I mdiv_ratio[0]:I pllen:I pllfwen_b:I powergood_vnn:I ratio[9]:I ratio[8]:I ratio[7]:I ratio[6]:I ratio[5]:I
* .PININFO ratio[4]:I ratio[3]:I ratio[2]:I ratio[1]:I ratio[0]:I ssc_cyc_to_peak_m1[8]:I ssc_cyc_to_peak_m1[7]:I ssc_cyc_to_peak_m1[6]:I
* .PININFO ssc_cyc_to_peak_m1[5]:I ssc_cyc_to_peak_m1[4]:I ssc_cyc_to_peak_m1[3]:I ssc_cyc_to_peak_m1[2]:I ssc_cyc_to_peak_m1[1]:I
* .PININFO ssc_cyc_to_peak_m1[0]:I ssc_en:I ssc_frac_step[23]:I ssc_frac_step[22]:I ssc_frac_step[21]:I ssc_frac_step[20]:I ssc_frac_step[19]:I
* .PININFO ssc_frac_step[18]:I ssc_frac_step[17]:I ssc_frac_step[16]:I ssc_frac_step[15]:I ssc_frac_step[14]:I ssc_frac_step[13]:I ssc_frac_step[12]:I
* .PININFO ssc_frac_step[11]:I ssc_frac_step[10]:I ssc_frac_step[9]:I ssc_frac_step[8]:I ssc_frac_step[7]:I ssc_frac_step[6]:I ssc_frac_step[5]:I
* .PININFO ssc_frac_step[4]:I ssc_frac_step[3]:I ssc_frac_step[2]:I ssc_frac_step[1]:I ssc_frac_step[0]:I tcapturedr:I tck:I tdi:I treg_en:I trst_n:I
* .PININFO tshiftdr:I tupdatedr:I vccdig_nom:I vccdist_nom:I vccldo_hv:I vcodiv_ratio[1]:I vcodiv_ratio[0]:I vnnaon_nom:I vss:I zdiv0_ratio[9]:I
* .PININFO zdiv0_ratio[8]:I zdiv0_ratio[7]:I zdiv0_ratio[6]:I zdiv0_ratio[5]:I zdiv0_ratio[4]:I zdiv0_ratio[3]:I zdiv0_ratio[2]:I zdiv0_ratio[1]:I
* .PININFO zdiv0_ratio[0]:I zdiv0_ratio_p5:I zdiv1_ratio[9]:I zdiv1_ratio[8]:I zdiv1_ratio[7]:I zdiv1_ratio[6]:I zdiv1_ratio[5]:I zdiv1_ratio[4]:I
* .PININFO zdiv1_ratio[3]:I zdiv1_ratio[2]:I zdiv1_ratio[1]:I zdiv1_ratio[0]:I zdiv1_ratio_p5:I clkpll:O clkpll0:O clkpll1:O idvdisable_bo:O
* .PININFO idvfreqao:O idvfreqbo:O idvpulseo:O idvtclko:O idvtctrlo:O idvtdo:O idvtreso:O lock:O odfx_fscan_sdo[2]:O odfx_fscan_sdo[1]:O
* .PININFO odfx_fscan_sdo[0]:O tdo:O view_dig_out[1]:O view_dig_out[0]:O viewanabus[1]:O viewanabus[0]:O
Xipll_ldo anadft_ldovfb anadft_ldovref vccpll_nom anadft_ldo clkref_i fz_ldo_bypass_a fz_ldo_extrefsel_a fz_ldo_faststart_a fz_ldo_fbtrim_a[3] fz_ldo_fbtrim_a[2] fz_ldo_fbtrim_a[1] fz_ldo_fbtrim_a[0] fz_ldo_reftrim_a[3] fz_ldo_reftrim_a[2] fz_ldo_reftrim_a[1] fz_ldo_reftrim_a[0] fz_ldo_vinvoltsel_a[1] fz_ldo_vinvoltsel_a[0] ldo_enable_a ldo_vref powergood_vnn_buf ta_ldo_hiz_debug ta_ldo_idq_debug vccdig_nom vccldo_hv vnnaon_nom vss fz_spare_a[4] powergood_vccdig ringpll__pll_ldo
Xidcp3_new vccpll_nom vss ringpll__ip22_topdecap1
Xidcp1 vccpll_nom vss ringpll__ip22_topdecap1
Xiip22_ringpll_hip adc_dig_out[9] adc_dig_out[8] adc_dig_out[7] adc_dig_out[6] adc_dig_out[5] adc_dig_out[4] adc_dig_out[3] adc_dig_out[2] adc_dig_out[1] adc_dig_out[0] adc_done pll_fbgen_clkfbmxh clkidvih clkplldiv0 clkplldiv1 clkpllmh pfdlockrstnh viewanabus[1] viewanabus[0] viewoutnh[1] viewoutnh[0] adc_chop_en adc_clkdiv[1] adc_clkdiv[0] adc_freeze adc_reset_bxxl adc_sel_in[2] adc_sel_in[1] adc_sel_in[0] adc_startxxh adc_use_vref anadft_ldo anadft_ldovfb anadft_ldovref reset_sync_bypassenxxnnnl reset_sync_bypassxxnnnl clkpostdistmh clkrefxxh earlylockxxh dfx_cp1_trim[4] dfx_cp1_trim[3] dfx_cp1_trim[2] dfx_cp1_trim[1] dfx_cp1_trim[0] dfx_cp2_trim[4] dfx_cp2_trim[3] dfx_cp2_trim[2] dfx_cp2_trim[1] dfx_cp2_trim[0] fz_cpnbias_a[1] fz_cpnbias_a[0] fz_dca_cb_a[1] fz_dca_cb_a[0] dfx_dca_ctrl[5] dfx_dca_ctrl[4] dfx_dca_ctrl[3] dfx_dca_ctrl[2] dfx_dca_ctrl[1] dfx_dca_ctrl[0] fz_irefgen_a[4] fz_irefgen_a[3] fz_irefgen_a[2] fz_irefgen_a[1] fz_irefgen_a[0] dfx_lockthresh[3] dfx_lockthresh[2] dfx_lockthresh[1] dfx_lockthresh[0] fz_lpfclksel_a fz_nopfdpwrgate_a fz_pfd_pw_a[2] fz_pfd_pw_a[1] fz_pfd_pw_a[0] fz_pfddly_a[1] fz_pfddly_a[0] dfx_skadj_ctrl[4] dfx_skadj_ctrl[3] dfx_skadj_ctrl[2] dfx_skadj_ctrl[1] dfx_skadj_ctrl[0] fz_spare_a[4] fz_spare_a[3] fz_spare_a[2] fz_spare_a[1] fz_spare_a[0] fz_startup_a[5] fz_startup_a[4] fz_startup_a[3] fz_startup_a[2] fz_startup_a[1] fz_startup_a[0] dfx_tight_loop fz_vcosel_a fz_vcotrim_a[10] fz_vcotrim_a[9] fz_vcotrim_a[8] fz_vcotrim_a[7] fz_vcotrim_a[6] fz_vcotrim_a[5] fz_vcotrim_a[4] fz_vcotrim_a[3] fz_vcotrim_a[2] fz_vcotrim_a[1] fz_vcotrim_a[0] idv_fub_idvgateennh lockxxl mdiv_ratio_a[5] mdiv_ratio_a[4] mdiv_ratio_a[3] mdiv_ratio_a[2] mdiv_ratio_a[1] mdiv_ratio_a[0] ssc_mod_dfx_clkmodmhx startup_gen_pfdenxxh dfx_powergood mash_ratio[9] mash_ratio[8] mash_ratio[7] mash_ratio[6] mash_ratio[5] mash_ratio[4] mash_ratio[3] mash_ratio[2] mash_ratio[1] mash_ratio[0] mash_halfintmxh zdiv0_ratio_a[9] zdiv0_ratio_a[8] zdiv0_ratio_a[7] zdiv0_ratio_a[6] zdiv0_ratio_a[5] zdiv0_ratio_a[4] zdiv0_ratio_a[3] zdiv0_ratio_a[2] zdiv0_ratio_a[1] zdiv0_ratio_a[0] zdiv1_ratio_a[9] zdiv1_ratio_a[8] zdiv1_ratio_a[7] zdiv1_ratio_a[6] zdiv1_ratio_a[5] zdiv1_ratio_a[4] zdiv1_ratio_a[3] zdiv1_ratio_a[2] zdiv1_ratio_a[1] zdiv1_ratio_a[0] rawlockxxl vctl_trim_fsm_vctlrdacshortxxh reset_sync_reset_b_xxnnnl ssc_directionmxh ta_spare[4] ta_spare[3] ta_spare[2] ta_spare[1] ta_spare[0] tllm_force_tight_loop tllm_gate_clk_trunk vccdig_nom vccdist_nom vccpll_nom ldo_vref vccldo_hv vcodiv_ratio_a[1] vcodiv_ratio_a[0] idv_rdacctlth[3] idv_rdacctlth[2] idv_rdacctlth[1] idv_rdacctlth[0] startup_gen_vctlrdacenxxh viewanaennh[1] viewanaennh[0] viewdigennh[1] viewdigennh[0] viewsel0[4] viewsel0[3] viewsel0[2] viewsel0[1] viewsel0[0] viewsel1[4] viewsel1[3] viewsel1[2] viewsel1[1] viewsel1[0] vss zdiv0_ratio_p5_a zdiv1_ratio_p5_a ringpll__ip22_ringpll_hip
Xiip22_ringpll_sip reset_sync_bypassxxnnnl dfx_cp1_trim[4] dfx_cp1_trim[3] dfx_cp1_trim[2] dfx_cp1_trim[1] dfx_cp1_trim[0] dfx_cp2_trim[4] dfx_cp2_trim[3] dfx_cp2_trim[2] dfx_cp2_trim[1] dfx_cp2_trim[0] fz_cpnbias_a[1] fz_cpnbias_a[0] fz_dca_cb_a[1] fz_dca_cb_a[0] dfx_dca_ctrl[5] dfx_dca_ctrl[4] dfx_dca_ctrl[3] dfx_dca_ctrl[2] dfx_dca_ctrl[1] dfx_dca_ctrl[0] fz_irefgen_a[4] fz_irefgen_a[3] fz_irefgen_a[2] fz_irefgen_a[1] fz_irefgen_a[0] fz_ldo_vinvoltsel_a[1] fz_ldo_vinvoltsel_a[0] fz_ldo_bypass_a fz_ldo_extrefsel_a fz_ldo_faststart_a fz_ldo_fbtrim_a[3] fz_ldo_fbtrim_a[2] fz_ldo_fbtrim_a[1] fz_ldo_fbtrim_a[0] fz_ldo_reftrim_a[3] fz_ldo_reftrim_a[2] fz_ldo_reftrim_a[1] fz_ldo_reftrim_a[0] dfx_lockthresh[3] dfx_lockthresh[2] dfx_lockthresh[1] dfx_lockthresh[0] fz_lpfclksel_a fz_nopfdpwrgate_a fz_pfd_pw_a[2] fz_pfd_pw_a[1] fz_pfd_pw_a[0] fz_pfddly_a[1] fz_pfddly_a[0] dfx_skadj_ctrl[4] dfx_skadj_ctrl[3] dfx_skadj_ctrl[2] dfx_skadj_ctrl[1] dfx_skadj_ctrl[0] fz_spare_a[4] fz_spare_a[3] fz_spare_a[2] fz_spare_a[1] fz_spare_a[0] fz_startup_a[5] fz_startup_a[4] fz_startup_a[3] fz_startup_a[2] fz_startup_a[1] fz_startup_a[0] dfx_tight_loop fz_vcosel_a fz_vcotrim_a[10] fz_vcotrim_a[9] fz_vcotrim_a[8] fz_vcotrim_a[7] fz_vcotrim_a[6] fz_vcotrim_a[5] fz_vcotrim_a[4] fz_vcotrim_a[3] fz_vcotrim_a[2] fz_vcotrim_a[1] fz_vcotrim_a[0] idvdisable_bo_i idvfreqao_i idvfreqbo_i idvpulseo_i idvtclko_i idvtctrlo_i idvtdo_i idvtreso_i ldo_enable_a mdiv_ratio_a[5] mdiv_ratio_a[4] mdiv_ratio_a[3] mdiv_ratio_a[2] mdiv_ratio_a[1] mdiv_ratio_a[0] reset_sync_reset_b_xxnnnl mash_ratio[9] mash_ratio[8] mash_ratio[7] mash_ratio[6] mash_ratio[5] mash_ratio[4] mash_ratio[3] mash_ratio[2] mash_ratio[1] mash_ratio[0] mash_halfintmxh tdo_i vcodiv_ratio_a[1] vcodiv_ratio_a[0] zdiv0_ratio_a[9] zdiv0_ratio_a[8] zdiv0_ratio_a[7] zdiv0_ratio_a[6] zdiv0_ratio_a[5] zdiv0_ratio_a[4] zdiv0_ratio_a[3] zdiv0_ratio_a[2] zdiv0_ratio_a[1] zdiv0_ratio_a[0] zdiv0_ratio_p5_a zdiv1_ratio_a[9] zdiv1_ratio_a[8] zdiv1_ratio_a[7] zdiv1_ratio_a[6] zdiv1_ratio_a[5] zdiv1_ratio_a[4] zdiv1_ratio_a[3] zdiv1_ratio_a[2] zdiv1_ratio_a[1] zdiv1_ratio_a[0] zdiv1_ratio_p5_a bypass_i clkref_i fraction_i[23] fraction_i[22] fraction_i[21] fraction_i[20] fraction_i[19] fraction_i[18] fraction_i[17] fraction_i[16] fraction_i[15] fraction_i[14] fraction_i[13] fraction_i[12] fraction_i[11] fraction_i[10] fraction_i[9] fraction_i[8] fraction_i[7] fraction_i[6] fraction_i[5] fraction_i[4] fraction_i[3] fraction_i[2] fraction_i[1] fraction_i[0] fz_cp1trim_i[4] fz_cp1trim_i[3] fz_cp1trim_i[2] fz_cp1trim_i[1] fz_cp1trim_i[0] fz_cp2trim_i[4] fz_cp2trim_i[3] fz_cp2trim_i[2] fz_cp2trim_i[1] fz_cp2trim_i[0] fz_cpnbias_i[1] fz_cpnbias_i[0] fz_dca_cb_i[1] fz_dca_cb_i[0] fz_dca_ctrl_i[5] fz_dca_ctrl_i[4] fz_dca_ctrl_i[3] fz_dca_ctrl_i[2] fz_dca_ctrl_i[1] fz_dca_ctrl_i[0] fz_irefgen_i[4] fz_irefgen_i[3] fz_irefgen_i[2] fz_irefgen_i[1] fz_irefgen_i[0] fz_ldo_vinvoltsel_i[1] fz_ldo_vinvoltsel_i[0] fz_ldo_bypass_i fz_ldo_extrefsel_i fz_ldo_faststart_i fz_ldo_fbtrim_i[3] fz_ldo_fbtrim_i[2] fz_ldo_fbtrim_i[1] fz_ldo_fbtrim_i[0] fz_ldo_reftrim_i[3] fz_ldo_reftrim_i[2] fz_ldo_reftrim_i[1] fz_ldo_reftrim_i[0] fz_lockcnt_i[2] fz_lockcnt_i[1] fz_lockcnt_i[0] fz_lockforce_i fz_lockstickyb_i fz_lockthresh_i[3] fz_lockthresh_i[2] fz_lockthresh_i[1] fz_lockthresh_i[0] fz_lpfclksel_i fz_nopfdpwrgate_i fz_pfd_pw_i[2] fz_pfd_pw_i[1] fz_pfd_pw_i[0] fz_pfddly_i[1] fz_pfddly_i[0] fz_skadj_i[4] fz_skadj_i[3] fz_skadj_i[2] fz_skadj_i[1] fz_skadj_i[0] fz_spare_i[4] fz_spare_i[3] fz_spare_i[2] fz_spare_i[1] fz_spare_i[0] fz_startup_i[5] fz_startup_i[4] fz_startup_i[3] fz_startup_i[2] fz_startup_i[1] fz_startup_i[0] fz_tight_loopb_i fz_vcosel_i fz_vcotrim_i[10] fz_vcotrim_i[9] fz_vcotrim_i[8] fz_vcotrim_i[7] fz_vcotrim_i[6] fz_vcotrim_i[5] fz_vcotrim_i[4] fz_vcotrim_i[3] fz_vcotrim_i[2] fz_vcotrim_i[1] fz_vcotrim_i[0] idvdisable_bi_i idvfreqai_i idvfreqbi_i idvpulsei_i idvtclki_i idvtctrli_i idvtdi_i idvtresi_i ldo_enable_i mash_order_plus_one_i mdiv_ratio_i[5] mdiv_ratio_i[4] mdiv_ratio_i[3] mdiv_ratio_i[2] mdiv_ratio_i[1] mdiv_ratio_i[0] pllen_i ratio_i[9] ratio_i[8] ratio_i[7] ratio_i[6] ratio_i[5] ratio_i[4] ratio_i[3] ratio_i[2] ratio_i[1] ratio_i[0] ssc_cyc_to_peak_m1_i[8] ssc_cyc_to_peak_m1_i[7] ssc_cyc_to_peak_m1_i[6] ssc_cyc_to_peak_m1_i[5] ssc_cyc_to_peak_m1_i[4] ssc_cyc_to_peak_m1_i[3] ssc_cyc_to_peak_m1_i[2] ssc_cyc_to_peak_m1_i[1] ssc_cyc_to_peak_m1_i[0] ssc_en_i ssc_frac_step_i[23] ssc_frac_step_i[22] ssc_frac_step_i[21] ssc_frac_step_i[20] ssc_frac_step_i[19] ssc_frac_step_i[18] ssc_frac_step_i[17] ssc_frac_step_i[16] ssc_frac_step_i[15] ssc_frac_step_i[14] ssc_frac_step_i[13] ssc_frac_step_i[12] ssc_frac_step_i[11] ssc_frac_step_i[10] ssc_frac_step_i[9] ssc_frac_step_i[8] ssc_frac_step_i[7] ssc_frac_step_i[6] ssc_frac_step_i[5] ssc_frac_step_i[4] ssc_frac_step_i[3] ssc_frac_step_i[2] ssc_frac_step_i[1] ssc_frac_step_i[0] tck_i tcapturedr_i tdi_i treg_en_i trst_n_i tshiftdr_i tupdatedr_i vccdig_nom vcodiv_ratio_i[1] vcodiv_ratio_i[0] vss zdiv0_ratio_i[9] zdiv0_ratio_i[8] zdiv0_ratio_i[7] zdiv0_ratio_i[6] zdiv0_ratio_i[5] zdiv0_ratio_i[4] zdiv0_ratio_i[3] zdiv0_ratio_i[2] zdiv0_ratio_i[1] zdiv0_ratio_i[0] zdiv0_ratio_p5_i zdiv1_ratio_i[9] zdiv1_ratio_i[8] zdiv1_ratio_i[7] zdiv1_ratio_i[6] zdiv1_ratio_i[5] zdiv1_ratio_i[4] zdiv1_ratio_i[3] zdiv1_ratio_i[2] zdiv1_ratio_i[1] zdiv1_ratio_i[0] zdiv1_ratio_p5_i ta_ldo_hiz_debug ta_ldo_idq_debug viewsel0[4] viewsel0[3] viewsel0[2] viewsel0[1] viewsel0[0] ta_spare[4] ta_spare[3] ta_spare[2] ta_spare[1] ta_spare[0] powergood_vccdig adc_dig_out[9] adc_dig_out[8] adc_dig_out[7] adc_dig_out[6] adc_dig_out[5] adc_dig_out[4] adc_dig_out[3] adc_dig_out[2] adc_dig_out[1] adc_dig_out[0] adc_done viewsel1[4] viewsel1[3] viewsel1[2] viewsel1[1] viewsel1[0] viewdigennh[1] viewdigennh[0] viewanaennh[1] viewanaennh[0] earlylockxxh lockxxl clkidvih rawlockxxl adc_startxxh adc_reset_bxxl adc_clkdiv[1] adc_clkdiv[0] adc_freeze adc_chop_en adc_use_vref adc_sel_in[2] adc_sel_in[1] adc_sel_in[0] pll_fbgen_clkfbmxh pfdlockrstnh reset_sync_bypassenxxnnnl dfx_powergood viewoutnh[1] viewoutnh[0] ssc_directionmxh idv_fub_idvgateennh idv_rdacctlth[3] idv_rdacctlth[2] idv_rdacctlth[1] idv_rdacctlth[0] ssc_mod_dfx_clkmodmhx startup_gen_pfdenxxh startup_gen_vctlrdacenxxh tllm_force_tight_loop vctl_trim_fsm_vctlrdacshortxxh tllm_gate_clk_trunk idfx_fscan_sdi_i[2] idfx_fscan_sdi_i[1] idfx_fscan_sdi_i[0] idfx_fscan_sdo_i[2] idfx_fscan_sdo_i[1] idfx_fscan_sdo_i[0] idfx_fscan_clkungate_i idfx_fscan_byprstb_i idfx_fscan_rstbypen_i idfx_fscan_shiften_i idfx_fscan_mode_i ringpll__ip22_ringpll_sip
Xidcp4_new vccpll_nom vss ringpll__ip22_topdecap2
Xidcp2 vccpll_nom vss ringpll__ip22_topdecap2
Xidcp5_new_extra vccpll_nom vss ringpll__ip22_topdecap_new_extra
Xiint bypass_i clkpll clkpll0 clkpll1 clkpostdistmh clkref_i clkrefxxh fraction_i[23] fraction_i[22] fraction_i[21] fraction_i[20] fraction_i[19] fraction_i[18] fraction_i[17] fraction_i[16] fraction_i[15] fraction_i[14] fraction_i[13] fraction_i[12] fraction_i[11] fraction_i[10] fraction_i[9] fraction_i[8] fraction_i[7] fraction_i[6] fraction_i[5] fraction_i[4] fraction_i[3] fraction_i[2] fraction_i[1] fraction_i[0] fz_cp1trim_i[4] fz_cp1trim_i[3] fz_cp1trim_i[2] fz_cp1trim_i[1] fz_cp1trim_i[0] fz_cp2trim_i[4] fz_cp2trim_i[3] fz_cp2trim_i[2] fz_cp2trim_i[1] fz_cp2trim_i[0] fz_cpnbias_i[1] fz_cpnbias_i[0] fz_dca_cb_i[1] fz_dca_cb_i[0] fz_dca_ctrl_i[5] fz_dca_ctrl_i[4] fz_dca_ctrl_i[3] fz_dca_ctrl_i[2] fz_dca_ctrl_i[1] fz_dca_ctrl_i[0] fz_irefgen_i[4] fz_irefgen_i[3] fz_irefgen_i[2] fz_irefgen_i[1] fz_irefgen_i[0] fz_ldo_bypass_i fz_ldo_extrefsel_i fz_ldo_faststart_i fz_ldo_fbtrim_i[3] fz_ldo_fbtrim_i[2] fz_ldo_fbtrim_i[1] fz_ldo_fbtrim_i[0] fz_ldo_reftrim_i[3] fz_ldo_reftrim_i[2] fz_ldo_reftrim_i[1] fz_ldo_reftrim_i[0] fz_ldo_vinvoltsel_i[1] fz_ldo_vinvoltsel_i[0] fz_lockcnt_i[2] fz_lockcnt_i[1] fz_lockcnt_i[0] fz_lockforce_i fz_lockstickyb_i fz_lockthresh_i[3] fz_lockthresh_i[2] fz_lockthresh_i[1] fz_lockthresh_i[0] fz_lpfclksel_i fz_nopfdpwrgate_i fz_pfd_pw_i[2] fz_pfd_pw_i[1] fz_pfd_pw_i[0] fz_pfddly_i[1] fz_pfddly_i[0] fz_skadj_i[4] fz_skadj_i[3] fz_skadj_i[2] fz_skadj_i[1] fz_skadj_i[0] fz_spare_i[4] fz_spare_i[3] fz_spare_i[2] fz_spare_i[1] fz_spare_i[0] fz_startup_i[5] fz_startup_i[4] fz_startup_i[3] fz_startup_i[2] fz_startup_i[1] fz_startup_i[0] fz_tight_loopb_i fz_vcosel_i fz_vcotrim_i[10] fz_vcotrim_i[9] fz_vcotrim_i[8] fz_vcotrim_i[7] fz_vcotrim_i[6] fz_vcotrim_i[5] fz_vcotrim_i[4] fz_vcotrim_i[3] fz_vcotrim_i[2] fz_vcotrim_i[1] fz_vcotrim_i[0] idfx_fscan_byprstb_i idfx_fscan_clkungate_i idfx_fscan_mode_i idfx_fscan_rstbypen_i idfx_fscan_sdi_i[2] idfx_fscan_sdi_i[1] idfx_fscan_sdi_i[0] idfx_fscan_shiften_i idvdisable_bi_i idvdisable_bo idvfreqai_i idvfreqao idvfreqbi_i idvfreqbo idvpulsei_i idvpulseo idvtclki_i idvtclko idvtctrli_i idvtctrlo idvtdi_i idvtdo idvtresi_i idvtreso ldo_enable_i lock mash_order_plus_one_i mdiv_ratio_i[5] mdiv_ratio_i[4] mdiv_ratio_i[3] mdiv_ratio_i[2] mdiv_ratio_i[1] mdiv_ratio_i[0] odfx_fscan_sdo[2] odfx_fscan_sdo[1] odfx_fscan_sdo[0] pllen_i pllfwen_b_i powergood_vccdig powergood_vnn_buf ratio_i[9] ratio_i[8] ratio_i[7] ratio_i[6] ratio_i[5] ratio_i[4] ratio_i[3] ratio_i[2] ratio_i[1] ratio_i[0] ssc_cyc_to_peak_m1_i[8] ssc_cyc_to_peak_m1_i[7] ssc_cyc_to_peak_m1_i[6] ssc_cyc_to_peak_m1_i[5] ssc_cyc_to_peak_m1_i[4] ssc_cyc_to_peak_m1_i[3] ssc_cyc_to_peak_m1_i[2] ssc_cyc_to_peak_m1_i[1] ssc_cyc_to_peak_m1_i[0] ssc_en_i ssc_frac_step_i[23] ssc_frac_step_i[22] ssc_frac_step_i[21] ssc_frac_step_i[20] ssc_frac_step_i[19] ssc_frac_step_i[18] ssc_frac_step_i[17] ssc_frac_step_i[16] ssc_frac_step_i[15] ssc_frac_step_i[14] ssc_frac_step_i[13] ssc_frac_step_i[12] ssc_frac_step_i[11] ssc_frac_step_i[10] ssc_frac_step_i[9] ssc_frac_step_i[8] ssc_frac_step_i[7] ssc_frac_step_i[6] ssc_frac_step_i[5] ssc_frac_step_i[4] ssc_frac_step_i[3] ssc_frac_step_i[2] ssc_frac_step_i[1] ssc_frac_step_i[0] tcapturedr_i tck_i tdi_i tdo treg_en_i trst_n_i tshiftdr_i tupdatedr_i vcodiv_ratio_i[1] vcodiv_ratio_i[0] view_dig_out[1] view_dig_out[0] zdiv0_ratio_i[9] zdiv0_ratio_i[8] zdiv0_ratio_i[7] zdiv0_ratio_i[6] zdiv0_ratio_i[5] zdiv0_ratio_i[4] zdiv0_ratio_i[3] zdiv0_ratio_i[2] zdiv0_ratio_i[1] zdiv0_ratio_i[0] zdiv0_ratio_p5_i zdiv1_ratio_i[9] zdiv1_ratio_i[8] zdiv1_ratio_i[7] zdiv1_ratio_i[6] zdiv1_ratio_i[5] zdiv1_ratio_i[4] zdiv1_ratio_i[3] zdiv1_ratio_i[2] zdiv1_ratio_i[1] zdiv1_ratio_i[0] zdiv1_ratio_p5_i bypass clkplldiv0 clkplldiv1 clkpllmh clkpostdist clkref fraction[23] fraction[22] fraction[21] fraction[20] fraction[19] fraction[18] fraction[17] fraction[16] fraction[15] fraction[14] fraction[13] fraction[12] fraction[11] fraction[10] fraction[9] fraction[8] fraction[7] fraction[6] fraction[5] fraction[4] fraction[3] fraction[2] fraction[1] fraction[0] fz_cp1trim[4] fz_cp1trim[3] fz_cp1trim[2] fz_cp1trim[1] fz_cp1trim[0] fz_cp2trim[4] fz_cp2trim[3] fz_cp2trim[2] fz_cp2trim[1] fz_cp2trim[0] fz_cpnbias[1] fz_cpnbias[0] fz_dca_cb[1] fz_dca_cb[0] fz_dca_ctrl[5] fz_dca_ctrl[4] fz_dca_ctrl[3] fz_dca_ctrl[2] fz_dca_ctrl[1] fz_dca_ctrl[0] fz_irefgen[4] fz_irefgen[3] fz_irefgen[2] fz_irefgen[1] fz_irefgen[0] fz_ldo_bypass fz_ldo_extrefsel fz_ldo_faststart fz_ldo_fbtrim[3] fz_ldo_fbtrim[2] fz_ldo_fbtrim[1] fz_ldo_fbtrim[0] fz_ldo_reftrim[3] fz_ldo_reftrim[2] fz_ldo_reftrim[1] fz_ldo_reftrim[0] fz_ldo_vinvoltsel[1] fz_ldo_vinvoltsel[0] fz_lockcnt[2] fz_lockcnt[1] fz_lockcnt[0] fz_lockforce fz_lockstickyb fz_lockthresh[3] fz_lockthresh[2] fz_lockthresh[1] fz_lockthresh[0] fz_lpfclksel fz_nopfdpwrgate fz_pfd_pw[2] fz_pfd_pw[1] fz_pfd_pw[0] fz_pfddly[1] fz_pfddly[0] fz_skadj[4] fz_skadj[3] fz_skadj[2] fz_skadj[1] fz_skadj[0] fz_spare[4] fz_spare[3] fz_spare[2] fz_spare[1] fz_spare[0] fz_startup[5] fz_startup[4] fz_startup[3] fz_startup[2] fz_startup[1] fz_startup[0] fz_tight_loopb fz_vcosel fz_vcotrim[10] fz_vcotrim[9] fz_vcotrim[8] fz_vcotrim[7] fz_vcotrim[6] fz_vcotrim[5] fz_vcotrim[4] fz_vcotrim[3] fz_vcotrim[2] fz_vcotrim[1] fz_vcotrim[0] idfx_fscan_byprstb idfx_fscan_clkungate idfx_fscan_mode idfx_fscan_rstbypen idfx_fscan_sdi[2] idfx_fscan_sdi[1] idfx_fscan_sdi[0] idfx_fscan_shiften idvdisable_bi idvdisable_bo_i idvfreqai idvfreqao_i idvfreqbi idvfreqbo_i idvpulsei idvpulseo_i idvtclki idvtclko_i idvtctrli idvtctrlo_i idvtdi idvtdo_i idvtresi idvtreso_i ldo_enable lockxxl mash_order_plus_one mdiv_ratio[5] mdiv_ratio[4] mdiv_ratio[3] mdiv_ratio[2] mdiv_ratio[1] mdiv_ratio[0] idfx_fscan_sdo_i[2] idfx_fscan_sdo_i[1] idfx_fscan_sdo_i[0] pllen pllfwen_b powergood_vnn ratio[9] ratio[8] ratio[7] ratio[6] ratio[5] ratio[4] ratio[3] ratio[2] ratio[1] ratio[0] ssc_cyc_to_peak_m1[8] ssc_cyc_to_peak_m1[7] ssc_cyc_to_peak_m1[6] ssc_cyc_to_peak_m1[5] ssc_cyc_to_peak_m1[4] ssc_cyc_to_peak_m1[3] ssc_cyc_to_peak_m1[2] ssc_cyc_to_peak_m1[1] ssc_cyc_to_peak_m1[0] ssc_en ssc_frac_step[23] ssc_frac_step[22] ssc_frac_step[21] ssc_frac_step[20] ssc_frac_step[19] ssc_frac_step[18] ssc_frac_step[17] ssc_frac_step[16] ssc_frac_step[15] ssc_frac_step[14] ssc_frac_step[13] ssc_frac_step[12] ssc_frac_step[11] ssc_frac_step[10] ssc_frac_step[9] ssc_frac_step[8] ssc_frac_step[7] ssc_frac_step[6] ssc_frac_step[5] ssc_frac_step[4] ssc_frac_step[3] ssc_frac_step[2] ssc_frac_step[1] ssc_frac_step[0] tcapturedr tck tdi tdo_i treg_en trst_n tshiftdr tupdatedr vccdig_nom vccdist_nom vcodiv_ratio[1] vcodiv_ratio[0] viewoutnh[1] viewoutnh[0] vnnaon_nom vss zdiv0_ratio[9] zdiv0_ratio[8] zdiv0_ratio[7] zdiv0_ratio[6] zdiv0_ratio[5] zdiv0_ratio[4] zdiv0_ratio[3] zdiv0_ratio[2] zdiv0_ratio[1] zdiv0_ratio[0] zdiv0_ratio_p5 zdiv1_ratio[9] zdiv1_ratio[8] zdiv1_ratio[7] zdiv1_ratio[6] zdiv1_ratio[5] zdiv1_ratio[4] zdiv1_ratio[3] zdiv1_ratio[2] zdiv1_ratio[1] zdiv1_ratio[0] zdiv1_ratio_p5 ringpll__pll_interface_icf
.ENDS

* /p/hdk/cad/pdk/pdk2229_r0.5HP1_21ww44.2/models/sram/cdl/be29/bitcells.cdl
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hccbit
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hccbitedge_flip
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hccllbitedge
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hdcbit
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hdcbitedge_flip
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hdclpbitedge
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hdrfbit
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22tprfbit2x2
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22tprfbitshrp
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22tprfbitshrp2x2_pg
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22viarombit2x1
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hccbitedge
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hccllbit
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hccllbitedge_flip
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hdcbitedge
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hdclpbit
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22hdclpbitedge_flip
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22tprfbit
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22tprfbitedge
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22tprfbitshrp2x2
*  View Name:	schematic
* *********************************
* *********************************
*  Library Name:	intel22sram
*  Cell Name:	x22tprfbitshrp_pg
*  View Name:	schematic
* *********************************
* *********************************************
* * Total SUBCKT Definitions In This File : 21
* *********************************************

* /p/hdk/cad/pdk/pdk2229_r0.5HP1_21ww44.2/models/custom/cdl/be29/intel22custom.cdl
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd0ru6ogdxnxdnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2pt0qnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2tmcqnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2tmpqnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2tmrqnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2tm0qnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn4000qnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xscrdjpn40aoxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre4trgqnxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre3runqnxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre3rarqnxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscretsubqtxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre4sufqtxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre4dnwqnxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre4dnwqnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre6dnwqnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddbxu2odgxnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpu2pt2qtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpuxdr0qtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpuxurrqtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpuxxcxqtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpuxurlqtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpu2tm2qtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpu4002qtxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre4scrqnxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre4000qnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre6000qnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdclpn2tm0qnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b882mfcs2sls6v0qtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn2pt2qnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn4nlpqnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xscrdjpe1og2xnxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xscrdjpe3og2xnxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xscrdjpe40aoxnxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xscrdjpn40aoxnxcnx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre4trgqnxhnx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe2ntgqtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd1ru6nwdqnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe2tr1qlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe2tmcqlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe2tr0qlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe2tm0qlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe2pt0qlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe4000qlxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe6000qlxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpu2pt0qtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpu2tm0qtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpu4000qtxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpu6000qtxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdclpu6000qtxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddjpu4ogdxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd1ru6ogdxnxdnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdd1ru6ogdxnxdnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru4tbnqtxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru4trgqtxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddjnu4ogdxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmdjnn60aoxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmd1xn40aoxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmdjpn60aoxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmdp2n60aoxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmd22n60aoxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe2tmnqtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe4ntgqtxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpe6ntgqtxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdclpe6ntgqtxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscrutsubqtxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru4sufqtxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru4sufqtxhnx_leakagefixed
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru4scrqtxhnx_500_leakagefixed
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmdp3n60aoxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpu6002qtxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru4scrqtxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddjnu4nwlqnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd1ru4nwlqnxcnx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmbgdh4410xmxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn6000qnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdclpn6000qnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmesdn62stxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre4scrqnxhnx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre4000qnxunx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru4scrqtxhnx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd1ru4nwlqnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xnac000e1000qlxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdd1ru6ogd8kvunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdclpn2pt0qnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdclpe6000qlxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru3rarqnxhnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmd23n60aoxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd2ru6ogdxnxdnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd2ru6ogdxnxdnx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru4tbnqtxhnx_500_leakagefixed
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru4trgqtxhnx_500_leakagefixed
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru4lk0qtxunx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdd2ru6ogdxnxdnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd1ru6ogdxnxdnx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre6000qnxunx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xnac000e1000qtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xthmesdn63stxnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd7ru6ogdxnxdnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdscre6000qnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xnac000e1000qnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xnac000e1000qmxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscre6s4pxnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdscre6s4pxnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdclpn6nlpqnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesddaxu2odgxnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdclpu6002qtxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xtfr6p0r2001qtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xtfr6p0r2010qtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd2ru6ogd8kvunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdclpn6nlpqnxcnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xtfr6p0r2100qtxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd3ru6ogdxnxdnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: fdk22b82lto_b88xesdd2ru6ogd8kvunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd4ru6ogdxnxdnx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd7ru6ogdxnxdnx_combo
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdd1ru6nwlqnxcnx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xesdscru6lk0qtxunx_500
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22custom
*  Cell Name: b88xtmd000h6000xnxunx
* ***********************************************************************
* ** End of intel22custom.cdl

* /p/hdk/cad/pdk/pdk2229_r0.5HP1_21ww44.2/libraries/tic/cdl/be29/intel22tapeout.cdl
* ***********************************************************************
*  auCdl Netlist:
*  Library Name:  ip2229appgrngplllib_ihdk_sch
*  Top Cell Name: ringpll
*  View Name:     schematic
*  Netlisted on:  Dec 15 02:54:07 2021
* ***********************************************************************
* ** Start of intel22tapeout.cdl
* ***********************************************************************
*  auCdl Netlist:
*  Library Name:  intel22tapeout
*  Top Cell Name:
*  View Name:     schematic
*  Netlisted on:  Feb  1 12:11:55 2021
* ***********************************************************************
* .RESVAL
* .CAPVAL
* .DIOPERI
* .DIOAREA
* .EQUATION
* .EXPAND_ON_M_FACTOR
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b88xdiccd0x6000xx2ulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b88xdicregx6000xx2ulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b88xprsdicntcdxqnxhlx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b88xprsdicntregqnxhlx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmbase
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmbase_small
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmcrnntxxxqnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmogddicwrapper
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmogdhs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmogdhs_route
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmogdhsdic
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmogdntdioqnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmogdntresqnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmogdntxtfqnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmpgddicwrapper
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmpgdhs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmpgdhs_route
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmpgdhsdic
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmpgdntdioqnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmpgdntresqnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmpgdntxtfqnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829emcrnxntprdqnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829emogdxntprdqnsulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829empgdxntprdqnsulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829ercrnxntprdqnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829erogdxntprdqnsulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829erpgdxntprdqnsulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829prsbackground
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829prshxxnt000qnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829prsuxxnt000qnxulx
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: fdk22tic29m1_diccd_cont
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: fdk22tic29m1_dicreg_cont
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_2x2_edm
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_2x2_er
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_2x2_er_edm
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_2x2_er_edm_prs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_2x2_prs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x4_er
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x4_edmxio
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x4_er_edmxio
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x4_er_edmxio_prs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x4_prs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x8_edmxio
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x8_er
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x8_er_edmxio
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x8_er_edmxio_prs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x8_prs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x4_edmxio
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x4_er
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x4_er_edmxio
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x4_er_edmxio_prs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x4_prs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x8_edmxio
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x8_er
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x8_er_edmxio
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x8_er_edmxio_prs
* *******************************************************
* *******************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x8_prs
* *******************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmogdntioxqnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x4_edm
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x4_er_edm
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x4_edm
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x4_er_edm
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x8_edm
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x8_er_edm
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: c4fcbga_dot29
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x4_er_edm_prs
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x8_edm
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x8_er_edm
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x8_er_edm_prs
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_4x8_er_edm_prs
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: b829edmpgdntioxqnxunx
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: c4etcsp_dot29
* ***********************************************************************
* ***********************************************************************
*  Library Name: intel22tapeout
*  Cell Name: tic22d29_s22_8x4_er_edm_prs
* ***********************************************************************
* ** End of intel22tapeout.cdl
